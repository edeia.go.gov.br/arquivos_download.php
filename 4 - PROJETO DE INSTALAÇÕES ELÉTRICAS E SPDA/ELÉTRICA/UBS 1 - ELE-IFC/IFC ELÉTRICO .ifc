Properties of the parts of a building model (IFC2X3), part 2 of 6

# IfcFlowFitting: Pontos de força - Uso geral (175)
Name | Largura (cm) | Profundidade (cm) | Posição | Quantidade | Descrição | Nome | Circuito_1 | Quadro_1 | Acessórios p/ eletrodutos - Caixa PVC - 4x2" | Circuito_2 | Comando_2 | Pavimento_do_circuito_2 | Quadro_2 | Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 2 funções
2 x  | 4.75 | 10.85 | Média | 1 | Tomada hexagonal (NBR 14136) - 2P+T 20 A a 1,20m do piso | 2P+T 20 A - média | 28 - Tug's Compressor | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 20A: 1
 | 4.75 | 10.85 | Média | 2 | 2 Tomadas hexagonais (NBR 14136) - 2P+T 10 A a 1,20m do piso | 2P+T 10A (2) - média | 22 - Tug's Expurgo | QD2 | 1 | 22 - Tug's Expurgo | Nenhum | TÉRREO | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 10A: 1
 | 4.75 | 10.85 | Média | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 1,10m do piso | 2P+T 10 A e 20A média | 22 - Tug's Expurgo | QD2 | 1 | 19 - Tug's 220v | Nenhum | TÉRREO | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 20A: 1; AltoQi_Builder-Ponto1 - sets with these values: 2
 | 4.75 | 10.85 | Baixa | 2 | 2 Tomadas hexagonais (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10A (2) - baixa | 22 - Tug's Expurgo | QD2 | 1 | 22 - Tug's Expurgo | Nenhum | TÉRREO | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 10A: 1
 | 4.75 | 10.85 | Baixa | 2 | 2 Tomadas hexagonais (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10A (2) - baixa | 23 - Tug's Odonto | QD2 | 1 | 23 - Tug's Odonto | Nenhum | TÉRREO | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 10A: 1
 | 4.75 | 10.85 | Baixa | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10 A - baixa | 60 - Tug's Espera | QD3 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1
 | 4.75 | 10.85 | Baixa | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A + 20A | 2P+T 10 A e 20A baixa | 23 - Tug's Odonto | QD2 | 1 | 43 - Tug's 220v | Nenhum | TÉRREO | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 20A: 1; AltoQi_Builder-Ponto1 - sets with these values: 2
2 x  | 10.85 | 4.75 | Piso | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A no piso | 2P+T 10 A - piso | 23 - Tug's Odonto | QD2 | AltoQi_QiBuilder-Itens_Associados - Acessórios p/ eletrodutos - Caixa alumínio 4"x2" - 3x4": 1; Dispositivo Elétrico - embutido - Placa 2x4" - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1
2 x  | 4.75 | 10.85 | Média | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 1,10m do piso | 2P+T 10 A e 20A média | 23 - Tug's Odonto | QD2 | 1 | 43 - Tug's 220v | Nenhum | TÉRREO | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 20A: 1; AltoQi_Builder-Ponto1 - sets with these values: 2
2 x  | 4.75 | 10.85 | Baixa | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10 A - baixa | 28 - Tug's Compressor | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1
 | 4.75 | 10.85 | Baixa | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10 A - baixa | 34 - Tug's Sala de Curativo | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1
2 x  | 4.75 | 10.85 | Média | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 1,20m do piso | 2P+T 10 A - média | 34 - Tug's Sala de Curativo | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1
 | 4.75 | 10.85 | Média | 2 | 2 Tomadas hexagonais (NBR 14136) - 2P+T 10 A a 1,20m do piso | 2P+T 10A (2) - média | 34 - Tug's Sala de Curativo | QD2 | 1 | 34 - Tug's Sala de Curativo | Nenhum | TÉRREO | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 10A: 1
 | 4.75 | 10.85 | Média | 2 | 2 Tomadas hexagonais (NBR 14136) - 2P+T 10 A a 1,20m do piso | 2P+T 10A (2) - média | 34 - Tug's Sala de Curativo | QD2 | 1 | 37 - Tug's 220v | Nenhum | TÉRREO | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 10A: 1
2 x  | 4.75 | 10.85 | Baixa | 2 | 2 Tomadas hexagonais (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10A (2) - baixa | 34 - Tug's Sala de Curativo | QD2 | 1 | 34 - Tug's Sala de Curativo | Nenhum | TÉRREO | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 10A: 1
 | 4.75 | 10.85 | Baixa | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A + 20A | 2P+T 10 A e 20A baixa | 41 - Tug's Corredor | QD2 | 1 | 38 - Tug's 220v | Nenhum | TÉRREO | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 20A: 1; AltoQi_Builder-Ponto1 - sets with these values: 2
 | 4.75 | 10.85 | Baixa | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10 A - baixa | 35 - Tug's Reidratação | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1
 | 4.75 | 10.85 | Média | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 1,10m do piso | 2P+T 10 A e 20A média | 35 - Tug's Reidratação | QD2 | 1 | 33 - Tug's 220v | Nenhum | TÉRREO | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 20A: 1; AltoQi_Builder-Ponto1 - sets with these values: 2
2 x  | 4.75 | 10.85 | Baixa | 2 | 2 Tomadas hexagonais (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10A (2) - baixa | 35 - Tug's Reidratação | QD2 | 1 | 35 - Tug's Reidratação | Nenhum | TÉRREO | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 10A: 1
 | 4.75 | 10.85 | Média | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 1,20m do piso | 2P+T 10 A - média | 35 - Tug's Reidratação | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1
2 x  | 4.75 | 10.85 | Baixa | 2 | 2 Tomadas hexagonais (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10A (2) - baixa | 36 - Tug's Aplicação de Medicamentos | QD2 | 1 | 36 - Tug's Aplicação de Medicamentos | Nenhum | TÉRREO | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 10A: 1
2 x  | 4.75 | 10.85 | Baixa | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10 A - baixa | 38 - Tug's 220v | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1
 | 4.75 | 10.85 | Baixa | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10 A - baixa | 39 - Tug's Consultório Indiferenciado | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1
2 x  | 4.75 | 10.85 | Baixa | 2 | 2 Tomadas hexagonais (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10A (2) - baixa | 39 - Tug's Consultório Indiferenciado | QD2 | 1 | 39 - Tug's Consultório Indiferenciado | Nenhum | TÉRREO | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 10A: 1
 | 4.75 | 10.85 | Média | 2 | 2 Tomadas hexagonais (NBR 14136) - 2P+T 10 A a 1,20m do piso | 2P+T 10A (2) - média | 39 - Tug's Consultório Indiferenciado | QD2 | 1 | 39 - Tug's Consultório Indiferenciado | Nenhum | TÉRREO | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 10A: 1
4 x  | 4.75 | 10.85 | Média | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 1,20m do piso | 2P+T 10 A - média | 39 - Tug's Consultório Indiferenciado | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1
 | 4.75 | 10.85 | Baixa | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A + 20A | 2P+T 10 A e 20A baixa | 39 - Tug's Consultório Indiferenciado | QD2 | 1 | 38 - Tug's 220v | Nenhum | TÉRREO | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 20A: 1; AltoQi_Builder-Ponto1 - sets with these values: 2
3 x  | 4.75 | 10.85 | Baixa | 2 | 2 Tomadas hexagonais (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10A (2) - baixa | 40 - Tug's Consultório Gineco | QD2 | 1 | 40 - Tug's Consultório Gineco | Nenhum | TÉRREO | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 10A: 1
2 x  | 4.75 | 10.85 | Média | 2 | 2 Tomadas hexagonais (NBR 14136) - 2P+T 10 A a 1,20m do piso | 2P+T 10A (2) - média | 40 - Tug's Consultório Gineco | QD2 | 1 | 40 - Tug's Consultório Gineco | Nenhum | TÉRREO | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 10A: 1
2 x  | 4.75 | 10.85 | Média | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 1,20m do piso | 2P+T 10 A - média | 40 - Tug's Consultório Gineco | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1
 | 4.75 | 10.85 | Baixa | 2 | 2 Tomadas hexagonais (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10A (2) - baixa | 41 - Tug's Corredor | QD2 | 1 | 41 - Tug's Corredor | Nenhum | TÉRREO | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 10A: 1
 | 4.75 | 10.85 | Baixa | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10 A - baixa | 37 - Tug's 220v | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1
2 x  | 4.75 | 10.85 | Baixa | 2 | 2 Tomadas hexagonais (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10A (2) - baixa | 42 - Tug's Sala Multiprofissional | QD2 | 1 | 42 - Tug's Sala Multiprofissional | Nenhum | TÉRREO | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 10A: 1
 | 4.75 | 10.85 | Média | 2 | 2 Tomadas hexagonais (NBR 14136) - 2P+T 10 A a 1,20m do piso | 2P+T 10A (2) - média | 42 - Tug's Sala Multiprofissional | QD2 | 1 | 42 - Tug's Sala Multiprofissional | Nenhum | TÉRREO | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 10A: 1
 | 4.75 | 10.85 | Baixa | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A + 20A | 2P+T 10 A e 20A baixa | 42 - Tug's Sala Multiprofissional | QD2 | 1 | 37 - Tug's 220v | Nenhum | TÉRREO | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 20A: 1; AltoQi_Builder-Ponto1 - sets with these values: 2
 | 4.75 | 10.85 | Baixa | 2 | 2 Tomadas hexagonais (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10A (2) - baixa | 42 - Tug's Sala Multiprofissional | QD2 | 1 | 37 - Tug's 220v | Nenhum | TÉRREO | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 10A: 1

# IfcFlowFitting: Saída horizontal para eletroduto sem tampa (2)
In: TÉRREO
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Posição: Teto
Identificação_Elemento - Aplicação: Conexão; Descrição: Saída horizontal para eletroduto; Nome: 100x50 mm; Classe: Eletrocalha furada tipo U pré-galv. quen; Tipo: Saída horizontal para eletroduto sem tampa; Rede: Elétrica
Pset_CableCarrierFittingTypeCommon - Reference: Saída horizontal para eletroduto sem tampa
AltoQi_QiBuilder-Itens_Associados - Eletrocalha furada tipo U pré-galv. quen - Acessórios para eletrocalha - Saída horizontal para eletroduto: 1

# IfcFlowFitting: Terminal sem tampa
In: TÉRREO
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Indicação: TM; Posição: Teto
Identificação_Elemento - Aplicação: Conexão; Descrição: Terminal; Nome: 100x50mm; Classe: Eletrocalha furada tipo U pré-galv. quen; Tipo: Terminal sem tampa; Rede: Elétrica
Pset_CableCarrierFittingTypeCommon - Reference: Terminal sem tampa
AltoQi_QiBuilder-Itens_Associados - Acessórios uso geral - Arruela lisa galvan. - 1/4": 24; Acessórios uso geral - Parafuso galvan. cabeça lentilha - 1/4"x5/8" máquina rosca total: 24; Acessórios uso geral - Porca sextavada galvan. - 1/4": 24; Eletrocalha furada tipo U pré-galv. quen - Tala plana perfurada - 50mm: 6; Eletrocalha furada tipo U pré-galv. quen - Terminal - 100x50mm chapa 18: 1

# IfcFlowSegment: Eletroduto tipo leve (451)
Type - PredefinedType: CONDUITSEGMENT
AltoQi_Builder - Comprimento máximo: 100 cm
Identificação_Elemento - Classe: Eletroduto PVC flexível; Tipo: Eletroduto tipo leve; Aplicação: Circular
Pset_CableCarrierSegmentTypeCommon - Reference: Eletroduto tipo leve
Pset_CableCarrierSegmentTypeCableLadderSegment - NominalLength: 100 cm
Name | In | Diâmetro interno (cm) | Diâmetro = Indicação | Espessura (cm) | Comprimento (cm) | Nome | Rede | Eletroduto PVC flexível - Eletroduto leve - 3/4" (cm) | Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Azul claro (cm) | Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Verde-amarelo (cm)
El1 | TÉRREO | 1.94 | ø3/4" | 0.15 | 390 | 3/4" | Elétrica | 390 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 390 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Verde-amarelo: 390 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Vermelho: 390 cm
El10 | TÉRREO | 1.94 | ø3/4" | 0.15 | 490 | 3/4" | Elétrica | 490 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 490 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Verde-amarelo: 490 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Vermelho: 490 cm
El100 | TÉRREO | 1.94 | ø3/4" | 0.15 | 305 | 3/4" | Elétrica | 305 | 305 | 305 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 305 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Branco: 305 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 305 cm
El101 | TÉRREO | 1.94 | ø3/4" | 0.15 | 471.63 | 3/4" | Elétrica | 471.625 | 471.625 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 471.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Branco: 471.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 471.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 471.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 471.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Preto: 471.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Verde-amarelo: 471.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Vermelho: 471.625 cm
El102 | TÉRREO | 1.94 | ø3/4" | 0.15 | 170 | 3/4" | Elétrica | 170 | 170 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 170 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 170 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 170 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Preto: 170 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Verde-amarelo: 170 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Vermelho: 170 cm
El103 | TÉRREO | 1.94 | ø3/4" | 0.15 | 325 | 3/4" | Elétrica | 325 | 325 | 325 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 325 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Branco: 325 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 325 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 325 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 325 cm
El104 | TÉRREO | 1.94 | ø3/4" | 0.15 | 335 | 3/4" | Elétrica | 335 | 335 | 335 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 335 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 335 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 335 cm
El105 | TÉRREO | 1.94 | ø3/4" | 0.15 | 90 | 3/4" | Elétrica | 90 | 90 | 90 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 90 cm
El106 | TÉRREO | 1.94 | ø3/4" | 0.15 | 40 | 3/4" | Elétrica | 40 | 40 | 40 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 40 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 40 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 40 cm
El107 | TÉRREO | 1.94 | ø3/4" | 0.15 | 90 | 3/4" | Elétrica | 90 | 90 | 90 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 90 cm
El109 | TÉRREO | 1.94 | ø3/4" | 0.15 | 370 | 3/4" | Elétrica | 370 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 370 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Verde-amarelo: 370 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Vermelho: 370 cm
El11 | TÉRREO | 1.94 | ø3/4" | 0.15 | 440 | 3/4" | Elétrica | 440 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 440 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Verde-amarelo: 440 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Vermelho: 440 cm
El110 | TÉRREO | 1.94 | ø3/4" | 0.15 | 326.63 | 3/4" | Elétrica | 326.625 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 326.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Verde-amarelo: 326.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Preto: 326.625 cm
El112 | TÉRREO | 1.94 | ø3/4" | 0.15 | 90 | 3/4" | Elétrica | 90 | 90 | 90 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 90 cm
El113 | TÉRREO | 1.94 | ø3/4" | 0.15 | 90 | 3/4" | Elétrica | 90 | 90 | 90 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 90 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 90 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 90 cm
El114 | TÉRREO | 1.94 | ø3/4" | 0.15 | 160 | 3/4" | Elétrica | 160 | 160 | 160 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 160 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 160 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 160 cm
El115 | TÉRREO | 1.94 | ø3/4" | 0.15 | 220 | 3/4" | Elétrica | 220 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 220 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Preto: 220 cm
El116 | TÉRREO | 1.94 | ø3/4" | 0.15 | 315 | 3/4" | Elétrica | 315 | 315 | 315 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 315 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 315 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 315 cm
El117 | TÉRREO | 1.94 | ø3/4" | 0.15 | 90 | 3/4" | Elétrica | 90 | 90 | 90 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 90 cm
El118 | TÉRREO | 1.94 | ø3/4" | 0.15 | 365 | 3/4" | Elétrica | 365 | 365 | 365 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 365 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Branco: 365 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 365 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 365 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 365 cm
El119 | TÉRREO | 1.94 | ø3/4" | 0.15 | 90 | 3/4" | Elétrica | 90 | 90 | 90 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 90 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 90 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 90 cm
El12 | TÉRREO | 1.94 | ø3/4" | 0.15 | 390 | 3/4" | Elétrica | 390 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 390 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Verde-amarelo: 390 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Vermelho: 390 cm
El120 | TÉRREO | 1.94 | ø3/4" | 0.15 | 10 | 3/4" | Elétrica | 10 | 10 | 10 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 10 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 10 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 10 cm
El121 | TÉRREO | 1.94 | ø3/4" | 0.15 | 481.63 | 3/4" | Elétrica | 481.625 | 481.625 | 481.625 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 481.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Branco: 481.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 481.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 481.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 481.625 cm
El122 | TÉRREO | 2.56 | ø1" | 0.32 | 561.63 | 1" | Elétrica |  | 1684.88 | 561.625 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 1123.25 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Vermelho: 1123.25 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 561.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 1123.25 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 1123.25 cm; Eletroduto PVC flexível - Eletroduto leve - 1": 561.625 cm
El123 | TÉRREO | 1.94 | ø3/4" | 0.15 | 771.63 | 3/4" | Elétrica | 771.625 | 1543.25 | 771.625 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 771.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Vermelho: 771.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 771.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 771.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 1543.25 cm
El124 | TÉRREO | 1.94 | ø3/4" | 0.15 | 551.63 | 3/4" | Elétrica | 551.625 | 1654.88 | 551.625 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 551.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Vermelho: 551.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 551.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 1103.25 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 1103.25 cm
El125 | TÉRREO | 2.56 | ø1" | 0.32 | 931.63 | 1" | Elétrica |  | 2794.88 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 931.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 931.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 1863.25 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Preto: 931.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Verde-amarelo: 931.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Vermelho: 931.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Preto: 931.625 cm; Eletroduto PVC flexível - Eletroduto leve - 1": 931.625 cm
El126 | TÉRREO | 1.94 | ø3/4" | 0.15 | 441.63 | 3/4" | Elétrica | 441.625 | 1324.88 | 441.625 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 441.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 883.25 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 441.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 883.25 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Preto: 441.625 cm
El127 | TÉRREO | 1.94 | ø3/4" | 0.15 | 701.63 | 3/4" | Elétrica | 1403.25 | 1403.25 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 701.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 1403.25 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Preto: 1403.25 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Verde-amarelo: 701.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Vermelho: 701.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Preto: 701.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Azul claro: 1403.25 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Branco: 701.625 cm
El128 | TÉRREO | 1.94 | ø3/4" | 0.15 | 931.63 | 3/4" | Elétrica | 931.625 | 2794.88 | 931.625 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 931.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 1863.25 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 2794.88 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Preto: 931.625 cm
El129 | TÉRREO | 2.56 | ø1" | 0.32 | 1213.38 | 1" | Elétrica |  |  | 1213.38 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 1213.38 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 1213.38 cm; Eletroduto PVC flexível - Eletroduto leve - 1": 1213.38 cm
El130 | TÉRREO | 2.56 | ø1" | 0.32 | 1313.38 | 1" | Elétrica |  |  | 1313.38 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 1313.38 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 1313.38 cm; Eletroduto PVC flexível - Eletroduto leve - 1": 1313.38 cm
El133 | TÉRREO | 1.94 | ø3/4" | 0.15 | 281.63 | 3/4" | Elétrica | 281.625 | 563.25 | 281.625 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 281.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Branco: 281.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 281.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 563.25 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 281.625 cm
El135 | TÉRREO | 1.94 | ø3/4" | 0.15 | 230 | 3/4" | Elétrica | 230 | 230 | 230 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 230 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Branco: 230 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 230 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 230 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 230 cm
El137 | TÉRREO | 1.94 | ø3/4" | 0.15 | 315 | 3/4" | Elétrica | 315 | 315 | 315 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 315 cm
El139 | TÉRREO | 1.94 | ø3/4" | 0.15 | 470 | 3/4" | Elétrica | 470 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 470 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Verde-amarelo: 470 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Preto: 470 cm
El140 | TÉRREO | 1.94 | ø3/4" | 0.15 | 445 | 3/4" | Elétrica | 445 | 445 | 445 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 890 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Branco: 445 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 445 cm
El141 | TÉRREO | 1.94 | ø3/4" | 0.15 | 70 | 3/4" | Elétrica | 70 | 70 | 70 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 70 cm
El142 | TÉRREO | 1.94 | ø3/4" | 0.15 | 390 | 3/4" | Elétrica | 390 | 390 | 390 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 390 cm
El143 | TÉRREO | 1.94 | ø3/4" | 0.15 | 771.6 | 3/4" | Elétrica | 771.6 |  | 771.6 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 2314.8 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 2314.8 cm
El144 | TÉRREO | 1.94 | ø3/4" | 0.15 | 881.6 | 3/4" | Elétrica | 881.6 |  | 881.6 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 1763.2 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 1763.2 cm
El145 | TÉRREO | 2.56 | ø1" | 0.32 | 226.6 | 1" | Elétrica | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto leve - 1": 453.2 cm; Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - ref. Inbrac Polivinil Flex Antichama - 16 mm² - Verde-amarelo: 226.6 cm; Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - ref. Inbrac Polivinil Flex Antichama - 25 mm² - Azul claro: 226.6 cm; Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - ref. Inbrac Polivinil Flex Antichama - 25 mm² - Branco: 226.6 cm; Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - ref. Inbrac Polivinil Flex Antichama - 25 mm² - Vermelho: 226.6 cm
El147 | TÉRREO | 1.94 | ø3/4" | 0.15 | 220 | 3/4" | Elétrica | 220 | 220 | 220 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 220 cm
El15 | TÉRREO | 1.94 | ø3/4" | 0.15 | 260 | 3/4" | Elétrica | 260 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 260 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Verde-amarelo: 260 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Vermelho: 260 cm
El150 | TÉRREO | 1.94 | ø3/4" | 0.15 | 60 | 3/4" | Elétrica | 60 | 60 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 60 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Preto: 60 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Verde-amarelo: 60 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Vermelho: 60 cm
El153 | TÉRREO | 1.94 | ø3/4" | 0.15 | 90 | 3/4" | Elétrica | 90 | 180 | 90 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 90 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 90 cm
El155 | TÉRREO | 1.94 | ø3/4" | 0.15 | 385 | 3/4" | Elétrica | 385 | 770 | 385 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 385 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 385 cm
El156 | TÉRREO | 1.94 | ø3/4" | 0.15 | 90 | 3/4" | Elétrica | 90 | 90 | 90 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 90 cm
El157 | TÉRREO | 1.94 | ø3/4" | 0.15 | 110 | 3/4" | Elétrica | 110 | 110 | 110 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 220 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 110 cm
El158 | TÉRREO | 1.94 | ø3/4" | 0.15 | 90 | 3/4" | Elétrica | 90 | 90 | 90 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 90 cm
El16 | TÉRREO | 1.94 | ø3/4" | 0.15 | 330 | 3/4" | Elétrica | 330 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 330 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Verde-amarelo: 330 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Vermelho: 330 cm
El161 | TÉRREO | 1.94 | ø3/4" | 0.15 | 505 | 3/4" | Elétrica | 505 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 505 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Verde-amarelo: 505 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Vermelho: 505 cm
El162 | TÉRREO | 1.94 | ø3/4" | 0.15 | 90 | 3/4" | Elétrica | 90 | 90 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 90 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Preto: 90 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Verde-amarelo: 90 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Vermelho: 90 cm
El163 | TÉRREO | 1.94 | ø3/4" | 0.15 | 375 | 3/4" | Elétrica | 375 | 375 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 375 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Preto: 375 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Verde-amarelo: 375 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Vermelho: 375 cm
El166 | TÉRREO | 1.94 | ø3/4" | 0.15 | 365 | 3/4" | Elétrica | 365 | 365 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 365 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 365 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Preto: 365 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Verde-amarelo: 365 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Vermelho: 365 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Preto: 365 cm
El167 | TÉRREO | 1.94 | ø3/4" | 0.15 | 260 | 3/4" | Elétrica | 260 |  | 260 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 260 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 260 cm
El168 | TÉRREO | 1.94 | ø3/4" | 0.15 | 870 | 3/4" | Elétrica | 870 |  | 870 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 1740 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 1740 cm
El169 | TÉRREO | 1.94 | ø3/4" | 0.15 | 245 | 3/4" | Elétrica | 245 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 245 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Verde-amarelo: 245 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Preto: 245 cm
El17 | TÉRREO | 1.94 | ø3/4" | 0.15 | 100 | 3/4" | Elétrica | 100 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 100 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Verde-amarelo: 100 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Branco: 100 cm
El170 | TÉRREO | 1.94 | ø3/4" | 0.15 | 90 | 3/4" | Elétrica | 90 | 90 | 90 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 90 cm
El171 | TÉRREO | 1.94 | ø3/4" | 0.15 | 335 | 3/4" | Elétrica | 335 | 335 | 335 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 670 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 335 cm
El172 | TÉRREO | 1.94 | ø3/4" | 0.15 | 170 | 3/4" | Elétrica | 170 | 170 | 170 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 170 cm
El175 | TÉRREO | 1.94 | ø3/4" | 0.15 | 490 | 3/4" | Elétrica | 490 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 490 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Verde-amarelo: 490 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Vermelho: 490 cm
El176 | TÉRREO | 2.56 | ø1" | 0.32 | 180 | 1" | Elétrica |  | 360 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 180 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 540 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 360 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Preto: 180 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Verde-amarelo: 180 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Vermelho: 180 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Preto: 180 cm; Eletroduto PVC flexível - Eletroduto leve - 1": 180 cm
El177 | TÉRREO | 1.94 | ø3/4" | 0.15 | 395 | 3/4" | Elétrica | 395 | 790 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 790 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 790 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Preto: 395 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Verde-amarelo: 395 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Vermelho: 395 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Preto: 395 cm
El178 | TÉRREO | 1.94 | ø3/4" | 0.15 | 250 | 3/4" | Elétrica | 250 | 500 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 250 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 500 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Preto: 250 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Verde-amarelo: 250 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Vermelho: 250 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Preto: 250 cm
El179 | TÉRREO | 1.94 | ø3/4" | 0.15 | 335 | 3/4" | Elétrica | 335 | 335 | 335 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 1005 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 335 cm
El18 | TÉRREO | 1.94 | ø3/4" | 0.15 | 485 | 3/4" | Elétrica | 485 | 485 | 485 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 485 cm
El180 | TÉRREO | 1.94 | ø3/4" | 0.15 | 90 | 3/4" | Elétrica | 90 | 90 | 90 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 90 cm
El182 | TÉRREO | 2.56 | ø1" | 0.32 | 210 | 1" | Elétrica |  | 630 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 210 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 210 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 210 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 420 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Preto: 210 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Verde-amarelo: 210 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Vermelho: 210 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Preto: 210 cm; Eletroduto PVC flexível - Eletroduto leve - 1": 210 cm
El183 | TÉRREO | 1.94 | ø3/4" | 0.15 | 180 | 3/4" | Elétrica | 180 | 360 | 180 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 180 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 180 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 180 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Preto: 180 cm
El184 | TÉRREO | 1.94 | ø3/4" | 0.15 | 210 | 3/4" | Elétrica | 210 | 210 | 210 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 210 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 210 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Preto: 210 cm
El185 | TÉRREO | 1.94 | ø3/4" | 0.15 | 170 | 3/4" | Elétrica | 170 | 510 | 170 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 170 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 170 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 340 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 170 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 340 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Preto: 170 cm
El186 | TÉRREO | 1.94 | ø3/4" | 0.15 | 180 | 3/4" | Elétrica | 180 | 360 | 180 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 180 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 180 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 180 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Preto: 180 cm
El187 | TÉRREO | 1.94 | ø3/4" | 0.15 | 90 | 3/4" | Elétrica | 90 | 90 | 90 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 180 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 90 cm
El188 | TÉRREO | 1.94 | ø3/4" | 0.15 | 335 | 3/4" | Elétrica | 335 | 335 | 335 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Vermelho: 335 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 335 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 670 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 335 cm
El189 | TÉRREO | 1.94 | ø3/4" | 0.15 | 190 | 3/4" | Elétrica | 190 | 570 | 190 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 380 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Vermelho: 380 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 190 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 190 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 190 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 190 cm
El19 | TÉRREO | 1.94 | ø3/4" | 0.15 | 295 | 3/4" | Elétrica | 295 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 295 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Verde-amarelo: 295 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Branco: 295 cm
El190 | TÉRREO | 1.94 | ø3/4" | 0.15 | 170 | 3/4" | Elétrica | 170 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 340 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Verde-amarelo: 170 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Vermelho: 340 cm
El191 | TÉRREO | 1.94 | ø3/4" | 0.15 | 325 | 3/4" | Elétrica | 325 | 325 | 325 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 325 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 325 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Preto: 325 cm
El192 | TÉRREO | 1.94 | ø3/4" | 0.15 | 90 | 3/4" | Elétrica | 90 | 90 | 90 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 90 cm
El193 | TÉRREO | 1.94 | ø3/4" | 0.15 | 385 | 3/4" | Elétrica | 385 | 385 | 385 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 770 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 385 cm
El194 | TÉRREO | 1.94 | ø3/4" | 0.15 | 90 | 3/4" | Elétrica | 90 | 90 | 90 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 90 cm
El195 | TÉRREO | 1.94 | ø3/4" | 0.15 | 325 | 3/4" | Elétrica | 325 | 325 | 325 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 975 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 325 cm
El196 | TÉRREO | 1.94 | ø3/4" | 0.15 | 305 | 3/4" | Elétrica | 305 | 610 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 610 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Preto: 305 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Verde-amarelo: 305 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Vermelho: 305 cm
El197 | TÉRREO | 1.94 | ø3/4" | 0.15 | 400 | 3/4" | Elétrica | 400 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 400 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Verde-amarelo: 400 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Vermelho: 400 cm
El198 | TÉRREO | 1.94 | ø3/4" | 0.15 | 90 | 3/4" | Elétrica | 90 | 90 | 90 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 90 cm
El199 | TÉRREO | 1.94 | ø3/4" | 0.15 | 160 | 3/4" | Elétrica | 160 | 160 | 160 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 160 cm
El2 | TÉRREO | 1.94 | ø3/4" | 0.15 | 460 | 3/4" | Elétrica | 460 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 460 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Verde-amarelo: 460 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Vermelho: 460 cm
El20 | TÉRREO | 1.94 | ø3/4" | 0.15 | 325 | 3/4" | Elétrica | 325 | 325 | 325 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 325 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Branco: 325 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 325 cm
El200 | TÉRREO | 1.94 | ø3/4" | 0.15 | 260 | 3/4" | Elétrica | 260 | 520 | 260 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 260 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Vermelho: 260 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 780 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 260 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 260 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 520 cm
El201 | TÉRREO | 1.94 | ø3/4" | 0.15 | 90 | 3/4" | Elétrica | 90 | 90 | 90 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 90 cm
El202 | TÉRREO | 1.94 | ø3/4" | 0.15 | 90 | 3/4" | Elétrica | 90 | 90 | 90 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 90 cm
