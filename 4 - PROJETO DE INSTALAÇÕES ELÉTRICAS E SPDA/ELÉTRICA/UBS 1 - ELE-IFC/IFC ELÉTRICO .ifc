Properties of the parts of a building model (IFC2X3), part 5 of 6

# IfcFlowSegment: Eletroduto tipo leve (451)
Name | In | Diâmetro interno (cm) | Diâmetro = Indicação | Espessura (cm) | Comprimento (cm) | Nome | Rede | Eletroduto PVC flexível - Eletroduto leve - 3/4" (cm) | Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Azul claro (cm) | Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Verde-amarelo (cm)
El79 | TÉRREO | 1.94 | ø3/4" | 0.15 | 150 | 3/4" | Elétrica | 150 | 150 | 150 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 150 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Branco: 150 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 150 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 150 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 150 cm
El80 | TÉRREO | 1.94 | ø3/4" | 0.15 | 641.63 | 3/4" | Elétrica | 641.625 | 641.625 | 641.625 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 641.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Branco: 641.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 641.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 641.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 641.625 cm
El81 | TÉRREO | 1.94 | ø3/4" | 0.15 | 170 | 3/4" | Elétrica | 170 | 170 | 170 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 170 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Branco: 170 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 170 cm
El82 | TÉRREO | 1.94 | ø3/4" | 0.15 | 365 | 3/4" | Elétrica | 365 |  | 365 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 365 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Branco: 365 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 365 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 365 cm
El84 | TÉRREO | 1.94 | ø3/4" | 0.15 | 425 | 3/4" | Elétrica | 425 | 425 | 425 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 425 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Branco: 425 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 425 cm
El85 | TÉRREO | 1.94 | ø3/4" | 0.15 | 541.63 | 3/4" | Elétrica | 541.625 | 1624.88 | 541.625 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 541.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Branco: 541.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 1624.88 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 541.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 541.625 cm
El86 | TÉRREO | 1.94 | ø3/4" | 0.15 | 365 | 3/4" | Elétrica | 365 | 365 | 365 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 730 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 365 cm
El87 | TÉRREO | 1.94 | ø3/4" | 0.15 | 90 | 3/4" | Elétrica | 90 | 90 | 90 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 90 cm
El88 | TÉRREO | 2.56 | ø1" | 0.32 | 1056.63 | 1" | Elétrica | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto leve - 1": 1056.62 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 6 mm² - Preto: 1056.62 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 6 mm² - Verde-amarelo: 1056.62 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 6 mm² - Branco: 1056.62 cm
El89 | TÉRREO | 1.94 | ø3/4" | 0.15 | 510 | 3/4" | Elétrica | 510 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 510 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Verde-amarelo: 510 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Vermelho: 510 cm
El9 | TÉRREO | 1.94 | ø3/4" | 0.15 | 380 | 3/4" | Elétrica | 380 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 380 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Verde-amarelo: 380 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Vermelho: 380 cm
El90 | TÉRREO | 1.94 | ø3/4" | 0.15 | 90 | 3/4" | Elétrica | 90 |  | 90 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 90 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 90 cm
El91 | TÉRREO | 1.94 | ø3/4" | 0.15 | 310 | 3/4" | Elétrica | 310 | 310 | 310 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 310 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 930 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Branco: 310 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 310 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 310 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 310 cm
El92 | TÉRREO | 1.94 | ø3/4" | 0.15 | 541.63 | 3/4" | Elétrica | 541.625 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 541.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Preto: 541.625 cm
El93 | TÉRREO | 1.94 | ø3/4" | 0.15 | 901.6 | 3/4" | Elétrica | 901.6 |  | 901.6 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 1803.2 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 1803.2 cm
El94 | TÉRREO | 1.94 | ø3/4" | 0.15 | 40 | 3/4" | Elétrica | 40 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Preto: 40 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Verde-amarelo: 40 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Vermelho: 40 cm
El95 | TÉRREO | 1.94 | ø3/4" | 0.15 | 335 | 3/4" | Elétrica | 335 | 335 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 335 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Preto: 335 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Verde-amarelo: 335 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Vermelho: 335 cm
El96 | TÉRREO | 1.94 | ø3/4" | 0.15 | 20 | 3/4" | Elétrica | 20 | 20 | 20 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 40 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 20 cm
El97 | TÉRREO | 1.94 | ø3/4" | 0.15 | 80 | 3/4" | Elétrica | 80 | 80 | 80 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 80 cm
El99 | TÉRREO | 1.94 | ø3/4" | 0.15 | 160 | 3/4" | Elétrica | 160 | 160 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 160 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Branco: 160 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 160 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 160 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 160 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Preto: 160 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Verde-amarelo: 160 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Vermelho: 160 cm
Lo1 | TÉRREO | 2.56 | ø1" | 0.32 | 1099.16 | 1" | Lógica | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto leve - 1": 1099.16 cm
Lo10 | TÉRREO | 1.94 | ø3/4" | 0.15 | 880 | 3/4" | Lógica | 880
Lo13 | TÉRREO | 1.94 | ø3/4" | 0.15 | 130 | 3/4" | Lógica | 130
Lo15 | TÉRREO | 1.94 | ø3/4" | 0.15 | 794.58 | 3/4" | Lógica | 794.58
Lo16 | TÉRREO | 2.56 | ø1" | 0.32 | 1374.58 | 1" | Lógica | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto leve - 1": 1374.58 cm
Lo2 | TÉRREO | 1.94 | ø3/4" | 0.15 | 110 | 3/4" | Lógica | 110
Lo3 | TÉRREO | 2.56 | ø1" | 0.32 | 1214.58 | 1" | Lógica | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto leve - 1": 1214.58 cm
Lo4 | TÉRREO | 2.56 | ø1" | 0.32 | 1216.6 | 1" | Lógica | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto leve - 1": 1216.6 cm
Lo5 | TÉRREO | 1.94 | ø3/4" | 0.15 | 904.58 | 3/4" | Lógica | 904.58
Lo6 | TÉRREO | 1.94 | ø3/4" | 0.15 | 504.58 | 3/4" | Lógica | 504.58
Lo7 | TÉRREO | 2.56 | ø1" | 0.32 | 964.58 | 1" | Lógica | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto leve - 1": 964.58 cm
Lo8 | TÉRREO | 2.56 | ø1" | 0.32 | 1323.4 | 1" | Lógica | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto leve - 1": 1323.4 cm
Lo9 | TÉRREO | 1.94 | ø3/4" | 0.15 | 919.16 | 3/4" | Lógica | 919.16
El1 | COBERTURA | 1.94 | ø3/4" | 0.15 | 330 | 3/4" | Elétrica | 330 |  | 330 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 330 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 330 cm
El10 | COBERTURA | 1.94 | ø3/4" | 0.15 | 80 | 3/4" | Elétrica | 80 |  | 80 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 80 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 80 cm
El11 | COBERTURA | 1.94 | ø3/4" | 0.15 | 160 | 3/4" | Elétrica | 160 |  | 160 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 160 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 160 cm
El12 | COBERTURA | 1.94 | ø3/4" | 0.15 | 200 | 3/4" | Elétrica | 200 |  | 200 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 200 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 200 cm
El13 | COBERTURA | 1.94 | ø3/4" | 0.15 | 140 | 3/4" | Elétrica | 140 |  | 140 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 140 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 140 cm
El14 | COBERTURA | 1.94 | ø3/4" | 0.15 | 140 | 3/4" | Elétrica | 140 |  | 140 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 140 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 140 cm
El15 | COBERTURA | 1.94 | ø3/4" | 0.15 | 140 | 3/4" | Elétrica | 140 |  | 140 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 140 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 140 cm
El16 | COBERTURA | 1.94 | ø3/4" | 0.15 | 140 | 3/4" | Elétrica | 140 |  | 140 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 140 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 140 cm
El17 | COBERTURA | 1.94 | ø3/4" | 0.15 | 210 | 3/4" | Elétrica | 210 |  | 210 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 210 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 210 cm
El18 | COBERTURA | 1.94 | ø3/4" | 0.15 | 140 | 3/4" | Elétrica | 140 |  | 140 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 140 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 140 cm
El19 | COBERTURA | 1.94 | ø3/4" | 0.15 | 60 | 3/4" | Elétrica | 60 |  | 60 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 60 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 60 cm
El2 | COBERTURA | 1.94 | ø3/4" | 0.15 | 140 | 3/4" | Elétrica | 140 |  | 140 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 140 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 140 cm
El20 | COBERTURA | 1.94 | ø3/4" | 0.15 | 140 | 3/4" | Elétrica | 140
El21 | COBERTURA | 1.94 | ø3/4" | 0.15 | 170 | 3/4" | Elétrica | 170
El22 | COBERTURA | 1.94 | ø3/4" | 0.15 | 140 | 3/4" | Elétrica | 140
El23 | COBERTURA | 1.94 | ø3/4" | 0.15 | 190 | 3/4" | Elétrica | 190
El24 | COBERTURA | 1.94 | ø3/4" | 0.15 | 140 | 3/4" | Elétrica | 140
El25 | COBERTURA | 1.94 | ø3/4" | 0.15 | 210 | 3/4" | Elétrica | 210
El26 | COBERTURA | 1.94 | ø3/4" | 0.15 | 140 | 3/4" | Elétrica | 140 |  | 140 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 140 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 140 cm
El27 | COBERTURA | 1.94 | ø3/4" | 0.15 | 200 | 3/4" | Elétrica | 200 |  | 200 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 200 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 200 cm
El28 | COBERTURA | 1.94 | ø3/4" | 0.15 | 290 | 3/4" | Elétrica | 290
El29 | COBERTURA | 1.94 | ø3/4" | 0.15 | 290 | 3/4" | Elétrica | 290 |  | 290 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 290 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 290 cm
El3 | COBERTURA | 1.94 | ø3/4" | 0.15 | 120 | 3/4" | Elétrica | 120
El30 | COBERTURA | 1.94 | ø3/4" | 0.15 | 140 | 3/4" | Elétrica | 140 |  | 140 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 140 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 140 cm
El31 | COBERTURA | 1.94 | ø3/4" | 0.15 | 10 | 3/4" | Elétrica | 10 |  | 10 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 10 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 10 cm
El32 | COBERTURA | 1.94 | ø3/4" | 0.15 | 290 | 3/4" | Elétrica | 290 |  | 290 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 290 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 290 cm
El33 | COBERTURA | 1.94 | ø3/4" | 0.15 | 140 | 3/4" | Elétrica | 140 |  | 140 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 140 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 140 cm
El34 | COBERTURA | 1.94 | ø3/4" | 0.15 | 290 | 3/4" | Elétrica | 290 |  | 290 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 290 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 290 cm
El35 | COBERTURA | 1.94 | ø3/4" | 0.15 | 140 | 3/4" | Elétrica | 140 |  | 140 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 140 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 140 cm
El36 | COBERTURA | 1.94 | ø3/4" | 0.15 | 380 | 3/4" | Elétrica | 380 |  | 380 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 380 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 380 cm
El37 | COBERTURA | 1.94 | ø3/4" | 0.15 | 160 | 3/4" | Elétrica | 160 |  | 160 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 160 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 160 cm
El38 | COBERTURA | 1.94 | ø3/4" | 0.15 | 140 | 3/4" | Elétrica | 140 |  | 140 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 140 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 140 cm
El4 | COBERTURA | 1.94 | ø3/4" | 0.15 | 100 | 3/4" | Elétrica | 100 |  | 100 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 100 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 100 cm
El5 | COBERTURA | 1.94 | ø3/4" | 0.15 | 140 | 3/4" | Elétrica | 140 |  | 140 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 140 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 140 cm
El6 | COBERTURA | 1.94 | ø3/4" | 0.15 | 70 | 3/4" | Elétrica | 70 |  | 70 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 70 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 70 cm
El7 | COBERTURA | 1.94 | ø3/4" | 0.15 | 140 | 3/4" | Elétrica | 140 |  | 140 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 140 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 140 cm
El8 | COBERTURA | 1.94 | ø3/4" | 0.15 | 170 | 3/4" | Elétrica | 170 |  | 170 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 170 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 170 cm
El9 | COBERTURA | 1.94 | ø3/4" | 0.15 | 140 | 3/4" | Elétrica | 140 |  | 140 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 140 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 140 cm
Tv1 | COBERTURA | 1.94 | ø3/4" | 0.15 | 200 | 3/4" | TV Cabo | 200
Tv10 | COBERTURA | 1.94 | ø3/4" | 0.15 | 200 | 3/4" | TV Cabo | 200
Tv2 | COBERTURA | 1.94 | ø3/4" | 0.15 | 200 | 3/4" | TV Cabo | 200
Tv3 | COBERTURA | 1.94 | ø3/4" | 0.15 | 200 | 3/4" | TV Cabo | 200
Tv4 | COBERTURA | 1.94 | ø3/4" | 0.15 | 200 | 3/4" | TV Cabo | 200
Tv5 | COBERTURA | 1.94 | ø3/4" | 0.15 | 200 | 3/4" | TV Cabo | 200
Tv6 | COBERTURA | 1.94 | ø3/4" | 0.15 | 390 | 3/4" | TV Cabo | 390
Tv7 | COBERTURA | 1.94 | ø3/4" | 0.15 | 200 | 3/4" | TV Cabo | 200
Tv8 | COBERTURA | 1.94 | ø3/4" | 0.15 | 200 | 3/4" | TV Cabo | 200
Tv9 | COBERTURA | 1.94 | ø3/4" | 0.15 | 200 | 3/4" | TV Cabo | 200

# IfcFlowSegment: Eletroduto tipo pesado (PEAD) (46)
In: TÉRREO
Type - PredefinedType: CONDUITSEGMENT
AltoQi_Builder - Comprimento máximo: 100 cm
Identificação_Elemento - Classe: Eletroduto PVC flexível; Tipo: Eletroduto tipo pesado (PEAD); Aplicação: Circular
Pset_CableCarrierSegmentTypeCommon - Reference: Eletroduto tipo pesado (PEAD)
Pset_CableCarrierSegmentTypeCableLadderSegment - NominalLength: 100 cm
Name | Diâmetro interno (cm) | Diâmetro | Espessura (cm) | Indicação | Comprimento (cm) | Nome | Rede | Eletroduto PVC flexível - Eletroduto pesado - 1.1/4" (cm)
El108 | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 240 | 1.1/4" | Elétrica | 240 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 240 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Vermelho: 240 cm
El13 | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 600 | 1.1/4" | Elétrica | 600 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 600 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Vermelho: 600 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Verde-amarelo: 600 cm
El131 | 4 | ø1 1/2" | 0.65 | ø1.1/2" | 211.63 | 1.1/2" | Elétrica | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - ref. Inbrac Polivinil Flex Antichama - 16 mm² - Verde-amarelo: 211.625 cm; Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - ref. Inbrac Polivinil Flex Antichama - 35 mm² - Azul claro: 211.625 cm; Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - ref. Inbrac Polivinil Flex Antichama - 35 mm² - Branco: 211.625 cm; Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - ref. Inbrac Polivinil Flex Antichama - 35 mm² - Preto: 211.625 cm; Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - ref. Inbrac Polivinil Flex Antichama - 35 mm² - Vermelho: 211.625 cm; Eletroduto PVC flexível - Eletroduto pesado - 1.1/2": 423.25 cm
El14 | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 560 | 1.1/4" | Elétrica | 560 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 560 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Branco: 560 cm
El148 | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 380 | 1.1/4" | Elétrica | 380 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Azul claro: 380 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 760 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Verde-amarelo: 380 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 380 cm
El154 | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 190 | 1.1/4" | Elétrica | 190 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Azul claro: 190 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 190 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Verde-amarelo: 190 cm
El159 | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 360 | 1.1/4" | Elétrica | 360 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Azul claro: 360 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 360 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Verde-amarelo: 360 cm
El160 | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 270 | 1.1/4" | Elétrica | 270 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 270 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Vermelho: 270 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Verde-amarelo: 270 cm
El164 | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 220 | 1.1/4" | Elétrica | 220 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 220 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Vermelho: 220 cm
El165 | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 590 | 1.1/4" | Elétrica | 590 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 590 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Vermelho: 590 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Verde-amarelo: 590 cm
El173 | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 20 | 1.1/4" | Elétrica | 20 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Azul claro: 20 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Verde-amarelo: 20 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 20 cm
El174 | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 250 | 1.1/4" | Elétrica | 250 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Azul claro: 250 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Verde-amarelo: 250 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 250 cm
El203 | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 240 | 1.1/4" | Elétrica | 240 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 240 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Vermelho: 240 cm
El210 | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 350 | 1.1/4" | Elétrica | 350 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Azul claro: 350 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Verde-amarelo: 350 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 350 cm
El23 | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 520 | 1.1/4" | Elétrica | 520 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Azul claro: 520 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Verde-amarelo: 520 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 520 cm
El247 | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 240 | 1.1/4" | Elétrica | 240 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 240 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Vermelho: 240 cm
El272 | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 460 | 1.1/4" | Elétrica | 460 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Azul claro: 460 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Preto: 460 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Verde-amarelo: 460 cm
El276 | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 290 | 1.1/4" | Elétrica | 290 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Azul claro: 290 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 580 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Verde-amarelo: 290 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 290 cm
El292 | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 590 | 1.1/4" | Elétrica | 590 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Azul claro: 590 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 590 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Preto: 590 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Verde-amarelo: 590 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Branco: 590 cm
El306 | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 290 | 1.1/4" | Elétrica | 290 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Azul claro: 290 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 290 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Preto: 290 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Verde-amarelo: 290 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Branco: 290 cm
El313 | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 400 | 1.1/4" | Elétrica | 400 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Azul claro: 400 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Verde-amarelo: 400 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 400 cm
El315 | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 340 | 1.1/4" | Elétrica | 340 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Azul claro: 340 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 340 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Verde-amarelo: 340 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 340 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 340 cm
El336 | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 140 | 1.1/4" | Elétrica | 140 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Azul claro: 140 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Verde-amarelo: 140 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 140 cm
El337 | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 140 | 1.1/4" | Elétrica | 140 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Azul claro: 140 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Verde-amarelo: 140 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 140 cm
El338 | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 190 | 1.1/4" | Elétrica | 190 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Azul claro: 190 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Verde-amarelo: 190 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 190 cm
El354 | 4 | ø1 1/2" | 0.65 | ø1.1/2" | 1163.2 | 1.1/2" | Elétrica | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 1163.2 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Vermelho: 1163.2 cm; Eletroduto PVC flexível - Eletroduto pesado - 1.1/2": 1163.2 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Verde-amarelo: 1163.2 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 1163.2 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 1163.2 cm
El361 | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 440 | 1.1/4" | Elétrica | 440 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Azul claro: 440 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Verde-amarelo: 440 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 440 cm
El364 | 5 | ø2" | 0.63 | ø2" | 1045 | 2" | Elétrica | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - ref. Inbrac Polivinil Flex Antichama - 16 mm² - Verde-amarelo: 3135 cm; Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - ref. Inbrac Polivinil Flex Antichama - 35 mm² - Azul claro: 1045 cm; Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - ref. Inbrac Polivinil Flex Antichama - 35 mm² - Branco: 1045 cm; Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - ref. Inbrac Polivinil Flex Antichama - 35 mm² - Preto: 1045 cm; Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - ref. Inbrac Polivinil Flex Antichama - 35 mm² - Vermelho: 1045 cm; Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - ref. Inbrac Polivinil Flex Antichama - 16 mm² - Azul claro: 1045 cm; Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - ref. Inbrac Polivinil Flex Antichama - 16 mm² - Branco: 1045 cm; Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - ref. Inbrac Polivinil Flex Antichama - 16 mm² - Preto: 1045 cm; Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - ref. Inbrac Polivinil Flex Antichama - 16 mm² - Vermelho: 1045 cm; Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - ref. Inbrac Polivinil Flex Antichama - 25 mm² - Azul claro: 1045 cm; Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - ref. Inbrac Polivinil Flex Antichama - 25 mm² - Branco: 1045 cm; Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - ref. Inbrac Polivinil Flex Antichama - 25 mm² - Vermelho: 1045 cm; Eletroduto PVC flexível - Eletroduto pesado - 2": 2090 cm
El406 | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 950 | 1.1/4" | Elétrica | 950 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 950 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Vermelho: 950 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Verde-amarelo: 950 cm
El407 | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 1060 | 1.1/4" | Elétrica | 1060 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 1060 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Vermelho: 1060 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Verde-amarelo: 1060 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 1060 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 1060 cm
El413 | 5 | ø2" | 0.63 | ø2" | 1026 | 2" | Elétrica | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - ref. Inbrac Polivinil Flex Antichama - 16 mm² - Verde-amarelo: 3078 cm; Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - ref. Inbrac Polivinil Flex Antichama - 35 mm² - Azul claro: 1026 cm; Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - ref. Inbrac Polivinil Flex Antichama - 35 mm² - Branco: 1026 cm; Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - ref. Inbrac Polivinil Flex Antichama - 35 mm² - Preto: 1026 cm; Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - ref. Inbrac Polivinil Flex Antichama - 35 mm² - Vermelho: 1026 cm; Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - ref. Inbrac Polivinil Flex Antichama - 16 mm² - Azul claro: 1026 cm; Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - ref. Inbrac Polivinil Flex Antichama - 16 mm² - Branco: 1026 cm; Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - ref. Inbrac Polivinil Flex Antichama - 16 mm² - Preto: 1026 cm; Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - ref. Inbrac Polivinil Flex Antichama - 16 mm² - Vermelho: 1026 cm; Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - ref. Inbrac Polivinil Flex Antichama - 25 mm² - Azul claro: 1026 cm; Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - ref. Inbrac Polivinil Flex Antichama - 25 mm² - Branco: 1026 cm; Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - ref. Inbrac Polivinil Flex Antichama - 25 mm² - Vermelho: 1026 cm; Eletroduto PVC flexível - Eletroduto pesado - 2": 2052 cm
El421 | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 290 | 1.1/4" | Elétrica | 290 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 290 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Branco: 290 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Azul claro: 290 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 290 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Preto: 290 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Verde-amarelo: 290 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Vermelho: 290 cm
El427 | 4 | ø1 1/2" | 0.65 | ø1.1/2" | 256 | 1.1/2" | Elétrica | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto pesado - 1.1/2": 512 cm; Cabo Unipolar - cobre - Isol. XLPE - 0,6/1kV - ref. Inbrac Crossvinil - 50 mm² - Azul claro: 256 cm; Cabo Unipolar - cobre - Isol. XLPE - 0,6/1kV - ref. Inbrac Crossvinil - 50 mm² - Branco: 256 cm; Cabo Unipolar - cobre - Isol. XLPE - 0,6/1kV - ref. Inbrac Crossvinil - 50 mm² - Preto: 256 cm; Cabo Unipolar - cobre - Isol. XLPE - 0,6/1kV - ref. Inbrac Crossvinil - 50 mm² - Vermelho: 256 cm
El44 | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 770 | 1.1/4" | Elétrica | 770 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Azul claro: 770 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 770 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Verde-amarelo: 770 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 770 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 770 cm
El5 | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 420.38 | 1.1/4" | Elétrica | 420.375 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 420.375 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Verde-amarelo: 420.375 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 420.375 cm
El6 | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 360.37 | 1.1/4" | Elétrica | 360.37 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 360.37 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Verde-amarelo: 360.37 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 360.37 cm
El63 | 4 | ø1 1/2" | 0.65 | ø1.1/2" | 1006.63 | 1.1/2" | Elétrica | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto pesado - 1.1/2": 1006.62 cm; Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - ref. Inbrac Polivinil Flex Antichama - 6 mm² - Azul claro: 1006.62 cm; Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - ref. Inbrac Polivinil Flex Antichama - 6 mm² - Branco: 1006.62 cm; Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - ref. Inbrac Polivinil Flex Antichama - 6 mm² - Preto: 1006.62 cm; Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - ref. Inbrac Polivinil Flex Antichama - 6 mm² - Verde-amarelo: 1006.62 cm
El7 | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 539.63 | 1.1/4" | Elétrica | 539.625 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 539.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Verde-amarelo: 539.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Branco: 539.625 cm
El8 | 4 | ø1 1/2" | 0.65 | ø1.1/2" | 1080.38 | 1.1/2" | Elétrica | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto pesado - 1.1/2": 1080.38 cm; Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - ref. Inbrac Polivinil Flex Antichama - 6 mm² - Azul claro: 1080.38 cm; Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - ref. Inbrac Polivinil Flex Antichama - 6 mm² - Branco: 1080.38 cm; Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - ref. Inbrac Polivinil Flex Antichama - 6 mm² - Preto: 1080.38 cm; Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - ref. Inbrac Polivinil Flex Antichama - 6 mm² - Verde-amarelo: 1080.38 cm
El83 | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 220 | 1.1/4" | Elétrica | 220 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 220 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Vermelho: 220 cm
El98 | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 400 | 1.1/4" | Elétrica | 400 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Azul claro: 400 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 800 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Verde-amarelo: 400 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 400 cm
Lo11 | 5 | ø2" | 0.63 | ø2" | 1594.58 | 2" | Lógica | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto pesado - 2": 1594.58 cm
Lo12 | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 543.4 | 1.1/4" | Lógica | 543.4
Lo14 | 4 | ø1 1/2" | 0.65 | ø1.1/2" | 1266.6 | 1.1/2" | Lógica | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto pesado - 1.1/2": 1266.6 cm
Lo17 | 4 | ø1 1/2" | 0.65 | ø1.1/2" | 1320 | 1.1/2" | Lógica | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto pesado - 1.1/2": 1320 cm
Lo18 | 4 | ø1 1/2" | 0.65 | ø1.1/2" | 1290 | 1.1/2" | Lógica | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto pesado - 1.1/2": 1290 cm

# IfcFlowSegment: Suspensão vertical - Fixação cabo/verg. sem tampa (5)
In: TÉRREO
Type - PredefinedType: CABLETRAYSEGMENT
AltoQi_Builder - Altura: 5 cm; Base: 10 cm; Comprimento máximo: 300 cm; Espessura: 0.12 cm; Indicação: #100x50
Identificação_Elemento - Nome: 100x50mm; Classe: Eletrocalha furada tipo U pré-galv. quen; Tipo: Suspensão vertical - Fixação cabo/verg. sem tampa; Rede: Elétrica; Aplicação: Retangular aberto
Pset_CableCarrierSegmentTypeCommon - Reference: Suspensão vertical - Fixação cabo/verg. sem tampa
Pset_CableCarrierSegmentTypeCableTraySegment - NominalHeight: 5 cm; NominalWidth: 10 cm
Pset_CableCarrierSegmentTypeCableLadderSegment - NominalLength: 300 cm
Name | Comprimento (cm) = Eletrocalha furada tipo U pré-galv. quen - Eletrocalha perfurada tipo U - 100x50mm chapa 18 (cm) | Acessórios uso geral - Arruela lisa galvan. - 1/4" | Acessórios uso geral - Arruela lisa galvan. - 3/8" = Acessórios uso geral - Parafuso galvan. cab. sext. - 3/8"x2.1/2" rosca total WW = Acessórios uso geral - Porca sextavada galvan. - 3/8" = Acessórios uso geral - Suporte para cabo de aço - 38x90mm = Acessórios uso geral - Vergalhão galvan. rosca total - 1/4"x - comp. p/ proj. = Eletrocalha furada tipo U pré-galv. quen - Suporte vertical - 70x96mm | Acessórios uso geral - Porca sextavada galvan. - 1/4" | Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - ref. Inbrac Polivinil Flex Antichama - 16 mm² - Verde-amarelo (cm) | Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - ref. Inbrac Polivinil Flex Antichama - 35 mm² - Azul claro (cm) = Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - ref. Inbrac Polivinil Flex Antichama - 35 mm² - Branco (cm) = Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - ref. Inbrac Polivinil Flex Antichama - 35 mm² - Preto (cm) = Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - ref. Inbrac Polivinil Flex Antichama - 35 mm² - Vermelho (cm) | Acessórios uso geral - Parafuso galvan. cabeça lentilha - 1/4"x5/8" máquina rosca total | Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - ref. Inbrac Polivinil Flex Antichama - 25 mm² - Azul claro (cm) = Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - ref. Inbrac Polivinil Flex Antichama - 25 mm² - Branco (cm) = Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - ref. Inbrac Polivinil Flex Antichama - 25 mm² - Vermelho (cm) | Eletrocalha furada tipo U pré-galv. quen - Tala plana perfurada - 50mm
EL111 | 60 | 2 | 1 | 2
EL134 | 90 | 3 | 1 | 3 | 90 | 90
EL149 | 1640 | 84 | 11 | 44 | 3280 | 1640 | 40 | 1640 | 10
EL365 | 830 | 39 | 6 | 23 | 2490 | 830 | 16 | 830 | 4 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - ref. Inbrac Polivinil Flex Antichama - 16 mm² - Azul claro: 830 cm; Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - ref. Inbrac Polivinil Flex Antichama - 16 mm² - Branco: 830 cm; Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - ref. Inbrac Polivinil Flex Antichama - 16 mm² - Preto: 830 cm; Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - ref. Inbrac Polivinil Flex Antichama - 16 mm² - Vermelho: 830 cm
EL368 | 320 | 17 | 3 | 9 | 640 | 320 | 8 | 320 | 2

# IfcFlowTerminal: Arandela (43)
In: TÉRREO
Type - PredefinedType: DIRECTIONSOURCE
AltoQi_Builder - Requer aterramento: Sim; Comprimento: 12.7 cm; Largura: 11.7 cm; Profundidade: 8 cm; Indicação: Aran; Posição: Alta
AltoQi_Builder-Ponto1 - Fator de potência (%): 90; Fluxo luminoso para tensão 127V: 4500 lm; Fluxo luminoso para tensão 12V: 0 lm; Fluxo luminoso para tensão 220V: 4500 lm; Número de lâmpadas: 1; Quantidade: 1; Rendimento (%): 100; Tipo de luminária: A3 (Direta); Tipo de ponto: Lâmpada
Identificação_Elemento - Aplicação: Caixa; Descrição: Arandela; Classe: Lâmpadas Led; Tipo: Arandela; Rede: Elétrica
Circuito - Pavimento_do_circuito_1: TÉRREO
Pset_LightFixtureTypeCommon - Reference: Arandela
Pset_LightFixtureTypeCommon-Ponto1 - NumberOfSource: 1
Pset_ElectricalDeviceCommon - HasProtectiveEarth: Sim
Name | Potência (W) | Nome | Circuito_1 | Comando_1 | Quadro_1 | Lâmpadas Led - Arandela - Arandela 5W
8 x  | 6 | Arandela 6W | 52 - Iluminação | Nenhum | QD3 | 1
4 x  | 12 | Arandela 12W | 9 - Iluminação | Nenhum | QD2 | AltoQi_QiBuilder-Itens_Associados - Lâmpadas Led - Arandela - Arandela 12W: 1
12 x  | 6 | Arandela 6W | 9 - Iluminação | Nenhum | QD2 | 1
 | 12 | Arandela 12W | 52 - Iluminação | Nenhum | QD3 | AltoQi_QiBuilder-Itens_Associados - Lâmpadas Led - Arandela - Arandela 12W: 1
4 x  | 24 | Arandela 24W | 50 - Iluminação | Nenhum | QD3 | AltoQi_QiBuilder-Itens_Associados - Lâmpadas Led - Arandela - Arandela 24W: 1
7 x  | 24 | Arandela 24W | 8 - Iluminação | Nenhum | QD2 | AltoQi_QiBuilder-Itens_Associados - Lâmpadas Led - Arandela - Arandela 24W: 1
2 x  | 6 | Arandela 6W | 51 - Iluminação | Nenhum | QD3 | 1
3 x  | 24 | Arandela 24W | 7 - Iluminação | Nenhum | QD2 | AltoQi_QiBuilder-Itens_Associados - Lâmpadas Led - Arandela - Arandela 24W: 1
 | 5 | Arandela 5W | 1 - Iluminação | a | QD1 | 1
 | 24 | Arandela 24W | 7 - Iluminação | u | QD2 | AltoQi_QiBuilder-Itens_Associados - Lâmpadas Led - Arandela - Arandela 24W: 1

# IfcFlowTerminal: Bloco autônomo (aclaramento) - parede (29)
In: TÉRREO
AltoQi_Builder - Requer aterramento: Não; Comprimento: 22.2 cm; Largura: 11.6 cm; Profundidade: 9.2 cm; Posição: Alta
AltoQi_Builder-Ponto1 - Fator de potência (%): 100; Fluxo luminoso para tensão 127V: 600 lm; Fluxo luminoso para tensão 12V: 600 lm; Fluxo luminoso para tensão 220V: 600 lm; Número de lâmpadas: 1; Potência (W): 12; Quantidade: 1; Rendimento (%): 100; Tipo de luminária: A1 (Direta); Tipo de ponto: Lâmpada
Identificação_Elemento - Aplicação: Caixa; Descrição: Bloco autônomo ilum. emergência a 2,20m do piso; Nome: Autonomia 3h - 600lm; Classe: Iluminação de emergência; Tipo: Bloco autônomo (aclaramento) - parede; Rede: Elétrica
Circuito - Comando_1: Nenhum; Pavimento_do_circuito_1: TÉRREO
Pset_LightFixtureTypeCommon - Reference: Bloco autônomo (aclaramento) - parede
Pset_LightFixtureTypeCommon-Ponto1 - NumberOfSource: 1
Pset_ElectricalDeviceCommon - HasProtectiveEarth: Não
AltoQi_QiBuilder-Itens_Associados - Acessórios p/ eletrodutos - Caixa PVC - 4x2": 1; Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - Placa 2x4" - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1; Iluminação de emergência - Bloco autônomo - aclaramento - Autonomia 3h - 600lm: 1
Name | Circuito_1 | Quadro_1
9 x  | 45 - Iluminação de Emergência | QD2
13 x  | 46 - Iluminação de Emergência | QD2
7 x  | 67 - Iluminação de Emergência | QD3

# IfcFlowTerminal: Classic (86)
In: TÉRREO
Type - PredefinedType: DIRECTIONSOURCE
AltoQi_Builder - Requer aterramento: Não; Comprimento: 10.56 cm; Largura: 10.56 cm; Profundidade: 6.05 cm; Indicação: Cla; Posição: Teto
AltoQi_Builder-Ponto1 - Fator de potência (%): 70; Fluxo luminoso para tensão 12V: 0 lm; Número de lâmpadas: 1; Quantidade: 1; Rendimento (%): 100; Tipo de luminária: A1 (Direta); Tipo de ponto: Lâmpada
Identificação_Elemento - Aplicação: Caixa; Classe: Lâmpadas Led; Tipo: Classic; Rede: Elétrica
Circuito - Pavimento_do_circuito_1: TÉRREO
Pset_LightFixtureTypeCommon - Reference: Classic
Pset_LightFixtureTypeCommon-Ponto1 - NumberOfSource: 1
Pset_ElectricalDeviceCommon - HasProtectiveEarth: Não
AltoQi_QiBuilder-Itens_Associados - Acessórios p/ eletrodutos - Caixa PVC octogonal - 3x3": 1; Luminária e acessórios - Soquete - base E 27: 1
Name | Fluxo luminoso para tensão 127V (lm) | Fluxo luminoso para tensão 220V (lm) | Potência (W) | Descrição | Nome | Circuito_1 | Comando_1 | Quadro_1
2 x  | 2452 | 2454 | 36 | Lâmpada Led 24W | 36 W | 6 - Iluminação | h | QD2 | AltoQi_QiBuilder-Itens_Associados - Lâmpadas Led - Classic - 36W: 1
 | 2452 | 2454 | 36 | Lâmpada Led 24W | 36 W | 7 - Iluminação | Nenhum | QD2 | AltoQi_QiBuilder-Itens_Associados - Lâmpadas Led - Classic - 36W: 1
8 x  | 7020 | 7020 | 60 | Lâmpada Led 60W | 60W | 51 - Iluminação | Nenhum | QD3 | AltoQi_QiBuilder-Itens_Associados - Lâmpadas Led - Classic A - 35 W: 1
 | 2452 | 2454 | 12 | Lâmpada Led 12W | 12 W | 52 - Iluminação | o1 | QD3 | AltoQi_QiBuilder-Itens_Associados - Lâmpadas Led - Classic A - 12 W: 1
 | 2452 | 2454 | 36 | Lâmpada Led 24W | 36 W | 7 - Iluminação | s | QD2 | AltoQi_QiBuilder-Itens_Associados - Lâmpadas Led - Classic - 36W: 1
2 x  | 2452 | 2454 | 36 | Lâmpada Led 24W | 36 W | 50 - Iluminação | g1 | QD3 | AltoQi_QiBuilder-Itens_Associados - Lâmpadas Led - Classic - 36W: 1
 | 2452 | 2454 | 36 | Lâmpada Led 24W | 36 W | 50 - Iluminação | h1 | QD3 | AltoQi_QiBuilder-Itens_Associados - Lâmpadas Led - Classic - 36W: 1
2 x  | 10000 | 10000 | 40 | Lâmpada Led 40W | 40 W | 50 - Iluminação | n1 | QD3 | AltoQi_QiBuilder-Itens_Associados - Lâmpadas Led - Classic A - 35 W: 1
4 x  | 2452 | 2454 | 36 | Lâmpada Led 24W | 36 W | 50 - Iluminação | f1 | QD3 | AltoQi_QiBuilder-Itens_Associados - Lâmpadas Led - Classic - 36W: 1
2 x  | 2452 | 2454 | 36 | Lâmpada Led 24W | 36 W | 50 - Iluminação | i1 | QD3 | AltoQi_QiBuilder-Itens_Associados - Lâmpadas Led - Classic - 36W: 1
 | 2452 | 2454 | 36 | Lâmpada Led 24W | 36 W | 7 - Iluminação | i | QD2 | AltoQi_QiBuilder-Itens_Associados - Lâmpadas Led - Classic - 36W: 1
2 x  | 2452 | 2454 | 36 | Lâmpada Led 24W | 36 W | 7 - Iluminação | k | QD2 | AltoQi_QiBuilder-Itens_Associados - Lâmpadas Led - Classic - 36W: 1
 | 2452 | 2454 | 19 | Lâmpada Led 19W | 19 W | 7 - Iluminação | l | QD2 | AltoQi_QiBuilder-Itens_Associados - Lâmpadas Led - Classic A - 35 W: 1
2 x  | 2452 | 2454 | 36 | Lâmpada Led 24W | 36 W | 8 - Iluminação | b1 | QD2 | AltoQi_QiBuilder-Itens_Associados - Lâmpadas Led - Classic - 36W: 1
 | 2452 | 2454 | 19 | Lâmpada Led 19W | 19 W | 8 - Iluminação | a1 | QD2 | AltoQi_QiBuilder-Itens_Associados - Lâmpadas Led - Classic A - 35 W: 1
2 x  | 2452 | 2454 | 36 | Lâmpada Led 24W | 36 W | 8 - Iluminação | z | QD2 | AltoQi_QiBuilder-Itens_Associados - Lâmpadas Led - Classic - 36W: 1
2 x  | 2452 | 2454 | 36 | Lâmpada Led 24W | 36 W | 8 - Iluminação | y | QD2 | AltoQi_QiBuilder-Itens_Associados - Lâmpadas Led - Classic - 36W: 1
2 x  | 10000 | 10000 | 40 | Lâmpada Led 40W | 40 W | 8 - Iluminação | x | QD2 | AltoQi_QiBuilder-Itens_Associados - Lâmpadas Led - Classic A - 35 W: 1
 | 2452 | 2454 | 36 | Lâmpada Led 24W | 36 W | 7 - Iluminação | p | QD2 | AltoQi_QiBuilder-Itens_Associados - Lâmpadas Led - Classic - 36W: 1
 | 2452 | 2454 | 36 | Lâmpada Led 24W | 36 W | 7 - Iluminação | o | QD2 | AltoQi_QiBuilder-Itens_Associados - Lâmpadas Led - Classic - 36W: 1
 | 2452 | 2454 | 36 | Lâmpada Led 24W | 36 W | 7 - Iluminação | n | QD2 | AltoQi_QiBuilder-Itens_Associados - Lâmpadas Led - Classic - 36W: 1
 | 2452 | 2454 | 36 | Lâmpada Led 24W | 36 W | 7 - Iluminação | m | QD2 | AltoQi_QiBuilder-Itens_Associados - Lâmpadas Led - Classic - 36W: 1
2 x  | 2452 | 2454 | 36 | Lâmpada Led 24W | 36 W | 7 - Iluminação | q | QD2 | AltoQi_QiBuilder-Itens_Associados - Lâmpadas Led - Classic - 36W: 1
2 x  | 10000 | 10000 | 40 | Lâmpada Led 40W | 40 W | 8 - Iluminação | e1 | QD2 | AltoQi_QiBuilder-Itens_Associados - Lâmpadas Led - Classic A - 35 W: 1
 | 2452 | 2454 | 36 | Lâmpada Led 24W | 36 W | 7 - Iluminação | r | QD2 | AltoQi_QiBuilder-Itens_Associados - Lâmpadas Led - Classic - 36W: 1
 | 2452 | 2454 | 12 | Lâmpada Led 12W | 12 W | 52 - Iluminação | p1 | QD3 | AltoQi_QiBuilder-Itens_Associados - Lâmpadas Led - Classic A - 12 W: 1
2 x  | 2452 | 2454 | 36 | Lâmpada Led 24W | 36 W | 8 - Iluminação | v | QD2 | AltoQi_QiBuilder-Itens_Associados - Lâmpadas Led - Classic - 36W: 1
 | 2452 | 2454 | 36 | Lâmpada Led 24W | 36 W | 7 - Iluminação | t | QD2 | AltoQi_QiBuilder-Itens_Associados - Lâmpadas Led - Classic - 36W: 1
2 x  | 2452 | 2454 | 36 | Lâmpada Led 24W | 36 W | 8 - Iluminação | w | QD2 | AltoQi_QiBuilder-Itens_Associados - Lâmpadas Led - Classic - 36W: 1
 | 2452 | 2454 | 19 | Lâmpada Led 19W | 19 W | 8 - Iluminação | d1 | QD2 | AltoQi_QiBuilder-Itens_Associados - Lâmpadas Led - Classic A - 35 W: 1
2 x  | 2452 | 2454 | 36 | Lâmpada Led 24W | 36 W | 8 - Iluminação | c1 | QD2 | AltoQi_QiBuilder-Itens_Associados - Lâmpadas Led - Classic - 36W: 1
4 x  | 10000 | 10000 | 40 | Lâmpada Led 40W | 40 W | 7 - Iluminação | j | QD2 | AltoQi_QiBuilder-Itens_Associados - Lâmpadas Led - Classic A - 35 W: 1
5 x  | 10000 | 10000 | 40 | Lâmpada Led 40W | 40 W | 6 - Iluminação | f | QD2 | AltoQi_QiBuilder-Itens_Associados - Lâmpadas Led - Classic A - 35 W: 1
8 x  | 10000 | 10000 | 40 | Lâmpada Led 40W | 40 W | 50 - Iluminação | j1 | QD3 | AltoQi_QiBuilder-Itens_Associados - Lâmpadas Led - Classic A - 35 W: 1
3 x  | 10000 | 10000 | 40 | Lâmpada Led 40W | 40 W | 50 - Iluminação | k1 | QD3 | AltoQi_QiBuilder-Itens_Associados - Lâmpadas Led - Classic A - 35 W: 1
 | 2452 | 2454 | 36 | Lâmpada Led 24W | 36 W | 50 - Iluminação | m1 | QD3 | AltoQi_QiBuilder-Itens_Associados - Lâmpadas Led - Classic - 36W: 1
3 x  | 2452 | 2454 | 36 | Lâmpada Led 24W | 36 W | 6 - Iluminação | e | QD2 | AltoQi_QiBuilder-Itens_Associados - Lâmpadas Led - Classic - 36W: 1
 | 2452 | 2454 | 19 | Lâmpada Led 19W | 19 W | 50 - Iluminação | l1 | QD3 | AltoQi_QiBuilder-Itens_Associados - Lâmpadas Led - Classic A - 35 W: 1
