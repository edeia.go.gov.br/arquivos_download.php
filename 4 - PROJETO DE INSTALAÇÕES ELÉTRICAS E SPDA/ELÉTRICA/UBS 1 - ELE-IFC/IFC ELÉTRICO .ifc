Properties of the parts of a building model (IFC2X3), part 3 of 6

# IfcFlowSegment: Eletroduto tipo leve (451)
Name | In | Diâmetro interno (cm) | Diâmetro = Indicação | Espessura (cm) | Comprimento (cm) | Nome | Rede | Eletroduto PVC flexível - Eletroduto leve - 3/4" (cm) | Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Azul claro (cm) | Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Verde-amarelo (cm)
El204 | TÉRREO | 1.94 | ø3/4" | 0.15 | 465 | 3/4" | Elétrica | 465 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 1395 cm
El205 | TÉRREO | 1.94 | ø3/4" | 0.15 | 90 | 3/4" | Elétrica | 90 | 90 | 90 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 90 cm
El206 | TÉRREO | 1.94 | ø3/4" | 0.15 | 265 | 3/4" | Elétrica | 265 | 265 | 265 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 265 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 265 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Preto: 265 cm
El207 | TÉRREO | 1.94 | ø3/4" | 0.15 | 90 | 3/4" | Elétrica | 90 | 90 | 90 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 90 cm
El208 | TÉRREO | 1.94 | ø3/4" | 0.15 | 365 | 3/4" | Elétrica | 365 | 365 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 1825 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 365 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Preto: 365 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Verde-amarelo: 365 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Vermelho: 365 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Preto: 365 cm
El209 | TÉRREO | 1.94 | ø3/4" | 0.15 | 160 | 3/4" | Elétrica | 160 | 160 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 160 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Preto: 160 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Verde-amarelo: 160 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Vermelho: 160 cm
El21 | TÉRREO | 1.94 | ø3/4" | 0.15 | 90 | 3/4" | Elétrica | 90 | 90 | 90 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 90 cm
El211 | TÉRREO | 1.94 | ø3/4" | 0.15 | 315 | 3/4" | Elétrica | 315 | 315 | 315 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 315 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 315 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Preto: 315 cm
El212 | TÉRREO | 1.94 | ø3/4" | 0.15 | 90 | 3/4" | Elétrica | 90 | 90 | 90 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 90 cm
El213 | TÉRREO | 1.94 | ø3/4" | 0.15 | 160 | 3/4" | Elétrica | 160 | 160 | 160 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 320 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 160 cm
El215 | TÉRREO | 1.94 | ø3/4" | 0.15 | 530 | 3/4" | Elétrica | 530 |  | 530 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 530 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 530 cm
El216 | TÉRREO | 1.94 | ø3/4" | 0.15 | 360 | 3/4" | Elétrica | 360 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 360 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 1080 cm
El217 | TÉRREO | 1.94 | ø3/4" | 0.15 | 310 | 3/4" | Elétrica | 310 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 310 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 620 cm
El218 | TÉRREO | 2.56 | ø1" | 0.32 | 320 | 1" | Elétrica |  | 320 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 320 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 320 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Preto: 640 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Verde-amarelo: 320 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Vermelho: 320 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Preto: 320 cm; Eletroduto PVC flexível - Eletroduto leve - 1": 320 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Azul claro: 640 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Branco: 320 cm
El219 | TÉRREO | 1.94 | ø3/4" | 0.15 | 290 | 3/4" | Elétrica | 580 | 580 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 290 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 870 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 580 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Preto: 580 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Verde-amarelo: 290 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Vermelho: 290 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Preto: 290 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Azul claro: 580 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Branco: 290 cm
El22 | TÉRREO | 1.94 | ø3/4" | 0.15 | 50 | 3/4" | Elétrica | 50 | 50 | 50 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 50 cm
El220 | TÉRREO | 1.94 | ø3/4" | 0.15 | 375 | 3/4" | Elétrica | 375 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 750 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Preto: 375 cm
El221 | TÉRREO | 1.94 | ø3/4" | 0.15 | 230 | 3/4" | Elétrica | 230 | 230 | 230 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 230 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Vermelho: 230 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 230 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 230 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 460 cm
El222 | TÉRREO | 1.94 | ø3/4" | 0.15 | 365 | 3/4" | Elétrica | 365 | 365 | 365 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Vermelho: 365 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 365 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 365 cm
El223 | TÉRREO | 1.94 | ø3/4" | 0.15 | 180 | 3/4" | Elétrica | 180 | 180 | 180 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 180 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Vermelho: 180 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 180 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 360 cm
El224 | TÉRREO | 1.94 | ø3/4" | 0.15 | 245 | 3/4" | Elétrica | 245 | 245 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 245 cm
El225 | TÉRREO | 1.94 | ø3/4" | 0.15 | 50 | 3/4" | Elétrica | 50 | 50 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 50 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Verde-amarelo: 50 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Azul claro: 50 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Branco: 50 cm
El226 | TÉRREO | 1.94 | ø3/4" | 0.15 | 90 | 3/4" | Elétrica | 90 | 90 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 90 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Verde-amarelo: 90 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Azul claro: 90 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Branco: 90 cm
El227 | TÉRREO | 1.94 | ø3/4" | 0.15 | 90 | 3/4" | Elétrica | 90 | 90 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 90 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Verde-amarelo: 90 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Azul claro: 90 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Branco: 90 cm
El228 | TÉRREO | 1.94 | ø3/4" | 0.15 | 395 | 3/4" | Elétrica | 395 | 395 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 395 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 395 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Preto: 395 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Verde-amarelo: 395 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Vermelho: 395 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Preto: 395 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Azul claro: 395 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Branco: 395 cm
El229 | TÉRREO | 1.94 | ø3/4" | 0.15 | 90 | 3/4" | Elétrica | 90 | 90 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 90 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Preto: 90 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Verde-amarelo: 90 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Vermelho: 90 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Azul claro: 90 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Branco: 90 cm
El230 | TÉRREO | 1.94 | ø3/4" | 0.15 | 405 | 3/4" | Elétrica | 405 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 405 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Preto: 405 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Verde-amarelo: 405 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Vermelho: 405 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Preto: 405 cm
El231 | TÉRREO | 1.94 | ø3/4" | 0.15 | 90 | 3/4" | Elétrica | 90 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Preto: 90 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Verde-amarelo: 90 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Vermelho: 90 cm
El232 | TÉRREO | 1.94 | ø3/4" | 0.15 | 180 | 3/4" | Elétrica | 180 | 180 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 180 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Preto: 180 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Verde-amarelo: 180 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Azul claro: 180 cm
El233 | TÉRREO | 1.94 | ø3/4" | 0.15 | 345 | 3/4" | Elétrica | 345 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Preto: 345 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Verde-amarelo: 345 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Azul claro: 345 cm
El234 | TÉRREO | 1.94 | ø3/4" | 0.15 | 90 | 3/4" | Elétrica | 90 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Preto: 90 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Verde-amarelo: 90 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Azul claro: 90 cm
El235 | TÉRREO | 1.94 | ø3/4" | 0.15 | 395 | 3/4" | Elétrica | 395 | 790 | 395 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 395 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 790 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 790 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Preto: 395 cm
El236 | TÉRREO | 1.94 | ø3/4" | 0.15 | 90 | 3/4" | Elétrica | 90 |  | 90 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 90 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 90 cm
El237 | TÉRREO | 1.94 | ø3/4" | 0.15 | 160 | 3/4" | Elétrica | 160 | 160 | 160 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 160 cm
El238 | TÉRREO | 1.94 | ø3/4" | 0.15 | 265 | 3/4" | Elétrica | 265 | 265 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 265 cm
El239 | TÉRREO | 1.94 | ø3/4" | 0.15 | 90 | 3/4" | Elétrica | 90 | 90 | 90 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 90 cm
El24 | TÉRREO | 1.94 | ø3/4" | 0.15 | 705 | 3/4" | Elétrica | 705 |  | 705 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 705 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 705 cm
El240 | TÉRREO | 1.94 | ø3/4" | 0.15 | 50 | 3/4" | Elétrica | 50 | 50 | 50 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 50 cm
El241 | TÉRREO | 1.94 | ø3/4" | 0.15 | 110 | 3/4" | Elétrica | 110 | 110 | 110 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 110 cm
El242 | TÉRREO | 1.94 | ø3/4" | 0.15 | 375 | 3/4" | Elétrica | 375 | 375 | 375 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Vermelho: 375 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 375 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 375 cm
El243 | TÉRREO | 1.94 | ø3/4" | 0.15 | 90 | 3/4" | Elétrica | 90 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Verde-amarelo: 90 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Azul claro: 90 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Branco: 90 cm
El244 | TÉRREO | 1.94 | ø3/4" | 0.15 | 385 | 3/4" | Elétrica | 385 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Verde-amarelo: 385 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Azul claro: 385 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Branco: 385 cm
El245 | TÉRREO | 1.94 | ø3/4" | 0.15 | 190 | 3/4" | Elétrica | 190 | 380 | 190 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 190 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Vermelho: 190 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 190 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 190 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 380 cm
El246 | TÉRREO | 1.94 | ø3/4" | 0.15 | 280 | 3/4" | Elétrica | 280 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 280 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Vermelho: 280 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 840 cm
El248 | TÉRREO | 1.94 | ø3/4" | 0.15 | 180 | 3/4" | Elétrica | 180 | 180 | 180 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 180 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Vermelho: 180 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 180 cm
El249 | TÉRREO | 1.94 | ø3/4" | 0.15 | 345 | 3/4" | Elétrica | 345 | 345 | 345 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Vermelho: 345 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 345 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 345 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 345 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 345 cm
El25 | TÉRREO | 1.94 | ø3/4" | 0.15 | 50 | 3/4" | Elétrica | 50 | 50 | 50 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 50 cm
El250 | TÉRREO | 1.94 | ø3/4" | 0.15 | 150 | 3/4" | Elétrica | 150 | 150 | 150 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 150 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 150 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 150 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 300 cm
El251 | TÉRREO | 1.94 | ø3/4" | 0.15 | 260 | 3/4" | Elétrica | 260
El252 | TÉRREO | 2.56 | ø1" | 0.32 | 1190 | 1" | Elétrica | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto leve - 1": 1190 cm
El253 | TÉRREO | 1.94 | ø3/4" | 0.15 | 90 | 3/4" | Elétrica | 90 | 90 | 90 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 90 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 90 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 90 cm
El254 | TÉRREO | 1.94 | ø3/4" | 0.15 | 380 | 3/4" | Elétrica | 380 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 380 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Verde-amarelo: 380 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Vermelho: 380 cm
El255 | TÉRREO | 1.94 | ø3/4" | 0.15 | 170 | 3/4" | Elétrica | 170 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 170 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 170 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Preto: 170 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Verde-amarelo: 170 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Vermelho: 170 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Preto: 170 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Azul claro: 170 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Branco: 170 cm
El256 | TÉRREO | 1.94 | ø3/4" | 0.15 | 245 | 3/4" | Elétrica | 245 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 245 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Preto: 245 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Verde-amarelo: 245 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Vermelho: 245 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Preto: 245 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Azul claro: 245 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Branco: 245 cm
El257 | TÉRREO | 1.94 | ø3/4" | 0.15 | 210 | 3/4" | Elétrica | 210 | 210 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 210 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 210 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Preto: 210 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Verde-amarelo: 210 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Vermelho: 210 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Preto: 210 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Azul claro: 210 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Branco: 210 cm
El258 | TÉRREO | 1.94 | ø3/4" | 0.15 | 325 | 3/4" | Elétrica | 325 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Verde-amarelo: 325 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Azul claro: 325 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Branco: 325 cm
El259 | TÉRREO | 1.94 | ø3/4" | 0.15 | 315 | 3/4" | Elétrica | 315 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 315 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Verde-amarelo: 315 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Preto: 315 cm
El26 | TÉRREO | 2.56 | ø1" | 0.32 | 1273.2 | 1" | Elétrica | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto leve - 1": 1273.2 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 6 mm² - Preto: 1273.2 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 6 mm² - Verde-amarelo: 1273.2 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 6 mm² - Vermelho: 1273.2 cm
El260 | TÉRREO | 2.56 | ø1" | 0.32 | 210 | 1" | Elétrica |  | 210 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 210 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 210 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 210 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Preto: 420 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Verde-amarelo: 210 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Vermelho: 210 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Preto: 210 cm; Eletroduto PVC flexível - Eletroduto leve - 1": 210 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Azul claro: 420 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Branco: 210 cm
El261 | TÉRREO | 1.94 | ø3/4" | 0.15 | 305 | 3/4" | Elétrica | 305 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Preto: 305 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Verde-amarelo: 305 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Azul claro: 305 cm
El262 | TÉRREO | 1.94 | ø3/4" | 0.15 | 220 | 3/4" | Elétrica | 220 | 220 | 220 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 220 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 220 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Preto: 220 cm
El263 | TÉRREO | 1.94 | ø3/4" | 0.15 | 170 | 3/4" | Elétrica | 170 | 510 | 170 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 170 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 170 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 340 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 510 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Preto: 170 cm
El264 | TÉRREO | 1.94 | ø3/4" | 0.15 | 325 | 3/4" | Elétrica | 325 | 325 | 325 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 325 cm
El265 | TÉRREO | 1.94 | ø3/4" | 0.15 | 325 | 3/4" | Elétrica | 325 | 650 | 325 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 650 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 650 cm
El267 | TÉRREO | 1.94 | ø3/4" | 0.15 | 530 | 3/4" | Elétrica | 530 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Preto: 530 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Verde-amarelo: 530 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Vermelho: 530 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Azul claro: 530 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Branco: 530 cm
El268 | TÉRREO | 1.94 | ø3/4" | 0.15 | 450 | 3/4" | Elétrica | 450 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 450 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Verde-amarelo: 450 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Vermelho: 450 cm
El269 | TÉRREO | 1.94 | ø3/4" | 0.15 | 90 | 3/4" | Elétrica | 90 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Verde-amarelo: 90 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Azul claro: 90 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Branco: 90 cm
El27 | TÉRREO | 1.94 | ø3/4" | 0.15 | 415 | 3/4" | Elétrica | 415 | 415 | 415 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 415 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 415 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 415 cm
El270 | TÉRREO | 1.94 | ø3/4" | 0.15 | 50 | 3/4" | Elétrica | 50 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Preto: 50 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Verde-amarelo: 50 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Azul claro: 50 cm
El271 | TÉRREO | 1.94 | ø3/4" | 0.15 | 90 | 3/4" | Elétrica | 90 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Preto: 90 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Verde-amarelo: 90 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Azul claro: 90 cm
El273 | TÉRREO | 1.94 | ø3/4" | 0.15 | 325 | 3/4" | Elétrica | 325 | 325 | 325 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 325 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 325 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Preto: 325 cm
El274 | TÉRREO | 1.94 | ø3/4" | 0.15 | 90 | 3/4" | Elétrica | 90 | 90 | 90 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 90 cm
El275 | TÉRREO | 1.94 | ø3/4" | 0.15 | 90 | 3/4" | Elétrica | 90 | 180 | 90 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 180 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 180 cm
El277 | TÉRREO | 1.94 | ø3/4" | 0.15 | 275 | 3/4" | Elétrica | 275 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 275 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Verde-amarelo: 275 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Preto: 275 cm
El278 | TÉRREO | 1.94 | ø3/4" | 0.15 | 120 | 3/4" | Elétrica | 120 | 120 | 120 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 120 cm
El279 | TÉRREO | 1.94 | ø3/4" | 0.15 | 150 | 3/4" | Elétrica | 150 | 150 | 150 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 150 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 150 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 150 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 300 cm
El28 | TÉRREO | 1.94 | ø3/4" | 0.15 | 90 | 3/4" | Elétrica | 90 | 90 | 90 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 90 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 90 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 90 cm
El280 | TÉRREO | 1.94 | ø3/4" | 0.15 | 385 | 3/4" | Elétrica | 385 | 385 | 385 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 385 cm
El281 | TÉRREO | 1.94 | ø3/4" | 0.15 | 355 | 3/4" | Elétrica | 355 | 355 | 355 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Vermelho: 355 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 355 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 355 cm
El282 | TÉRREO | 1.94 | ø3/4" | 0.15 | 180 | 3/4" | Elétrica | 180 | 180 | 180 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 180 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Vermelho: 180 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 180 cm
El283 | TÉRREO | 1.94 | ø3/4" | 0.15 | 90 | 3/4" | Elétrica | 90 | 90 | 90 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 90 cm
El284 | TÉRREO | 1.94 | ø3/4" | 0.15 | 70 | 3/4" | Elétrica | 70 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Preto: 70 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Verde-amarelo: 70 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Vermelho: 70 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Azul claro: 70 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Branco: 70 cm
El285 | TÉRREO | 1.94 | ø3/4" | 0.15 | 70 | 3/4" | Elétrica | 70 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Preto: 70 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Verde-amarelo: 70 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Azul claro: 70 cm
El286 | TÉRREO | 1.94 | ø3/4" | 0.15 | 70 | 3/4" | Elétrica | 70 | 70 | 70 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 70 cm
El287 | TÉRREO | 1.94 | ø3/4" | 0.15 | 230 | 3/4" | Elétrica | 230 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 230 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Vermelho: 230 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 690 cm
El288 | TÉRREO | 1.94 | ø3/4" | 0.15 | 405 | 3/4" | Elétrica | 405 | 405 | 405 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 405 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 810 cm
El289 | TÉRREO | 1.94 | ø3/4" | 0.15 | 70 | 3/4" | Elétrica | 70 | 70 | 70 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 70 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 140 cm
El29 | TÉRREO | 1.94 | ø3/4" | 0.15 | 350 | 3/4" | Elétrica | 350 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 350 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Verde-amarelo: 350 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Vermelho: 350 cm
El290 | TÉRREO | 1.94 | ø3/4" | 0.15 | 315 | 3/4" | Elétrica | 315 | 315 | 315 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 315 cm
El291 | TÉRREO | 1.94 | ø3/4" | 0.15 | 355 | 3/4" | Elétrica | 355 | 355 | 355 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Vermelho: 355 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 355 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 355 cm
El293 | TÉRREO | 1.94 | ø3/4" | 0.15 | 345 | 3/4" | Elétrica | 345 | 345 | 345 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 345 cm
El294 | TÉRREO | 1.94 | ø3/4" | 0.15 | 90 | 3/4" | Elétrica | 90 | 90 | 90 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 90 cm
El295 | TÉRREO | 1.94 | ø3/4" | 0.15 | 405 | 3/4" | Elétrica | 405 | 405 | 405 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 405 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Branco: 405 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 405 cm
El296 | TÉRREO | 1.94 | ø3/4" | 0.15 | 90 | 3/4" | Elétrica | 90 | 90 | 90 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 90 cm
El297 | TÉRREO | 1.94 | ø3/4" | 0.15 | 440 | 3/4" | Elétrica | 440 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 440 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Verde-amarelo: 440 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Vermelho: 440 cm
El298 | TÉRREO | 1.94 | ø3/4" | 0.15 | 355 | 3/4" | Elétrica | 355 | 355 | 355 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 355 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Branco: 355 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 355 cm
El299 | TÉRREO | 1.94 | ø3/4" | 0.15 | 240 | 3/4" | Elétrica | 240 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 240 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Vermelho: 240 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 720 cm
El3 | TÉRREO | 1.94 | ø3/4" | 0.15 | 680 | 3/4" | Elétrica | 680 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 680 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Verde-amarelo: 680 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Vermelho: 680 cm
El30 | TÉRREO | 1.94 | ø3/4" | 0.15 | 170 | 3/4" | Elétrica | 170 | 170 | 170 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 170 cm
El300 | TÉRREO | 1.94 | ø3/4" | 0.15 | 250 | 3/4" | Elétrica | 250 | 250 | 250 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 250 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Branco: 250 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 250 cm
El301 | TÉRREO | 1.94 | ø3/4" | 0.15 | 110 | 3/4" | Elétrica | 110
El302 | TÉRREO | 1.94 | ø3/4" | 0.15 | 901.63 | 3/4" | Elétrica | 901.625 | 901.625 | 901.625 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 901.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Branco: 901.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 901.625 cm
El303 | TÉRREO | 1.94 | ø3/4" | 0.15 | 380 | 3/4" | Elétrica | 380 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 380 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Verde-amarelo: 380 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Vermelho: 380 cm
El304 | TÉRREO | 1.94 | ø3/4" | 0.15 | 350 | 3/4" | Elétrica | 350 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 350 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Verde-amarelo: 350 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Preto: 350 cm
El305 | TÉRREO | 1.94 | ø3/4" | 0.15 | 330 | 3/4" | Elétrica | 330 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 330 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Verde-amarelo: 330 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Preto: 330 cm
El307 | TÉRREO | 1.94 | ø3/4" | 0.15 | 120 | 3/4" | Elétrica | 120 | 120 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 120 cm
El308 | TÉRREO | 1.94 | ø3/4" | 0.15 | 355 | 3/4" | Elétrica | 355 | 1065 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 355 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 710 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Preto: 355 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Verde-amarelo: 355 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Branco: 355 cm
El309 | TÉRREO | 1.94 | ø3/4" | 0.15 | 665 | 3/4" | Elétrica | 665 | 1995 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 665 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 1330 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Preto: 665 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Verde-amarelo: 665 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Branco: 665 cm
El31 | TÉRREO | 1.94 | ø3/4" | 0.15 | 240 | 3/4" | Elétrica | 240 | 240 | 240 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 240 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 240 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Branco: 240 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 240 cm
El310 | TÉRREO | 1.94 | ø3/4" | 0.15 | 345 | 3/4" | Elétrica | 345 | 690 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 345 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 345 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Preto: 345 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Verde-amarelo: 345 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Branco: 345 cm
El311 | TÉRREO | 1.94 | ø3/4" | 0.15 | 100 | 3/4" | Elétrica | 100 | 200 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 100 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 100 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Preto: 100 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Verde-amarelo: 100 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Branco: 100 cm
El312 | TÉRREO | 1.94 | ø3/4" | 0.15 | 635 | 3/4" | Elétrica | 635 |  | 635 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 635 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 635 cm
El314 | TÉRREO | 1.94 | ø3/4" | 0.15 | 180 | 3/4" | Elétrica | 180 | 180 | 180 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 180 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 180 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 180 cm
El316 | TÉRREO | 1.94 | ø3/4" | 0.15 | 345 | 3/4" | Elétrica | 345 | 345 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 1380 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Branco: 345 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 345 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Preto: 345 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Verde-amarelo: 345 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Branco: 345 cm
El317 | TÉRREO | 1.94 | ø3/4" | 0.15 | 90 | 3/4" | Elétrica | 90 | 90 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 90 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Preto: 90 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Verde-amarelo: 90 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Branco: 90 cm
El318 | TÉRREO | 1.94 | ø3/4" | 0.15 | 90 | 3/4" | Elétrica | 90
El319 | TÉRREO | 1.94 | ø3/4" | 0.15 | 395 | 3/4" | Elétrica | 395 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Vermelho: 395 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 790 cm
El32 | TÉRREO | 1.94 | ø3/4" | 0.15 | 425 | 3/4" | Elétrica | 425 | 425 | 425 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 425 cm
El320 | TÉRREO | 1.94 | ø3/4" | 0.15 | 160 | 3/4" | Elétrica | 160 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 160 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 160 cm
El321 | TÉRREO | 2.56 | ø1" | 0.32 | 761.63 | 1" | Elétrica |  | 2284.88 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 761.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Branco: 761.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 761.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 1523.25 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Preto: 761.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Verde-amarelo: 761.625 cm; Eletroduto PVC flexível - Eletroduto leve - 1": 761.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Branco: 761.625 cm
El322 | TÉRREO | 1.94 | ø3/4" | 0.15 | 310 | 3/4" | Elétrica | 310 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 930 cm
El323 | TÉRREO | 1.94 | ø3/4" | 0.15 | 160 | 3/4" | Elétrica | 160 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 160 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 160 cm
El324 | TÉRREO | 1.94 | ø3/4" | 0.15 | 190 | 3/4" | Elétrica | 190 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 190 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 190 cm
El325 | TÉRREO | 1.94 | ø3/4" | 0.15 | 523.2 | 3/4" | Elétrica | 523.2 |  | 523.2 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 523.2 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 523.2 cm
El326 | TÉRREO | 1.94 | ø3/4" | 0.15 | 90 | 3/4" | Elétrica | 90 | 90 | 90 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 90 cm
El327 | TÉRREO | 1.94 | ø3/4" | 0.15 | 80 | 3/4" | Elétrica | 80 | 80 | 80 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 80 cm
El328 | TÉRREO | 1.94 | ø3/4" | 0.15 | 415 | 3/4" | Elétrica | 415 | 415 | 415 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 415 cm
El329 | TÉRREO | 1.94 | ø3/4" | 0.15 | 200 | 3/4" | Elétrica | 200 | 200 | 200 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 200 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 200 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Branco: 200 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 200 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 200 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 200 cm
El33 | TÉRREO | 1.94 | ø3/4" | 0.15 | 90 | 3/4" | Elétrica | 90 | 90 | 90 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 90 cm
El330 | TÉRREO | 1.94 | ø3/4" | 0.15 | 140 | 3/4" | Elétrica | 140 | 140 | 140 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 140 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Branco: 140 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 140 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 140 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 140 cm
El331 | TÉRREO | 1.94 | ø3/4" | 0.15 | 375 | 3/4" | Elétrica | 375 | 375 | 375 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 375 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Branco: 375 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 375 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 375 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 375 cm
El332 | TÉRREO | 1.94 | ø3/4" | 0.15 | 335 | 3/4" | Elétrica | 335 | 335 | 335 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 335 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 335 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 335 cm
El333 | TÉRREO | 1.94 | ø3/4" | 0.15 | 90 | 3/4" | Elétrica | 90 | 90 | 90 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 90 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 90 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 90 cm
El334 | TÉRREO | 1.94 | ø3/4" | 0.15 | 70 | 3/4" | Elétrica | 70 | 70 | 70 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 70 cm
El335 | TÉRREO | 1.94 | ø3/4" | 0.15 | 50 | 3/4" | Elétrica | 50 | 50 | 50 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 50 cm
