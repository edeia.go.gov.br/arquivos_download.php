Properties of the parts of a building model (IFC2X3), part 4 of 6

# IfcFlowSegment: Eletroduto tipo leve (451)
Name | In | Diâmetro interno (cm) | Diâmetro = Indicação | Espessura (cm) | Comprimento (cm) | Nome | Rede | Eletroduto PVC flexível - Eletroduto leve - 3/4" (cm) | Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Azul claro (cm) | Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Verde-amarelo (cm)
El339 | TÉRREO | 1.94 | ø3/4" | 0.15 | 70 | 3/4" | Elétrica | 70 | 70 | 70 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 70 cm
El34 | TÉRREO | 1.94 | ø3/4" | 0.15 | 240 | 3/4" | Elétrica | 240 | 240 | 240 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 240 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Branco: 240 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 240 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 240 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 240 cm
El340 | TÉRREO | 1.94 | ø3/4" | 0.15 | 90 | 3/4" | Elétrica | 90 | 90 | 90 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 90 cm
El341 | TÉRREO | 1.94 | ø3/4" | 0.15 | 435 | 3/4" | Elétrica | 435 | 435 | 435 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 435 cm
El342 | TÉRREO | 1.94 | ø3/4" | 0.15 | 380 | 3/4" | Elétrica | 380 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 380 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Verde-amarelo: 380 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Vermelho: 380 cm
El343 | TÉRREO | 1.94 | ø3/4" | 0.15 | 350 | 3/4" | Elétrica | 350 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 350 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Verde-amarelo: 350 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Preto: 350 cm
El344 | TÉRREO | 1.94 | ø3/4" | 0.15 | 365 | 3/4" | Elétrica | 365 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 365 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Verde-amarelo: 365 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Preto: 365 cm
El345 | TÉRREO | 1.94 | ø3/4" | 0.15 | 235 | 3/4" | Elétrica | 235 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 235 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Verde-amarelo: 235 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Branco: 235 cm
El346 | TÉRREO | 1.94 | ø3/4" | 0.15 | 140 | 3/4" | Elétrica | 140 | 140 | 140 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 140 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 140 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 140 cm
El347 | TÉRREO | 1.94 | ø3/4" | 0.15 | 181.63 | 3/4" | Elétrica | 181.625 | 363.25 | 181.625 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 181.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Branco: 181.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 181.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 181.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 363.25 cm
El348 | TÉRREO | 1.94 | ø3/4" | 0.15 | 558.2 | 3/4" | Elétrica | 558.199 | 1116.4 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 1116.4 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Branco: 558.199 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 1116.4 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Preto: 558.199 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Verde-amarelo: 558.199 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Preto: 558.199 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Branco: 558.199 cm
El349 | TÉRREO | 1.94 | ø3/4" | 0.15 | 216.63 | 3/4" | Elétrica | 216.625 | 216.625 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 216.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Preto: 216.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Verde-amarelo: 216.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Vermelho: 216.625 cm
El35 | TÉRREO | 1.94 | ø3/4" | 0.15 | 385 | 3/4" | Elétrica | 385 | 385 | 385 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 385 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Branco: 385 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 385 cm
El350 | TÉRREO | 2.56 | ø1" | 0.32 | 831.63 | 1" | Elétrica |  | 2494.88 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 831.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Branco: 831.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 831.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 1663.25 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Preto: 831.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Verde-amarelo: 831.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Vermelho: 831.625 cm; Eletroduto PVC flexível - Eletroduto leve - 1": 831.625 cm
El351 | TÉRREO | 1.94 | ø3/4" | 0.15 | 561.63 | 3/4" | Elétrica | 561.625 | 1684.88 | 561.625 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 561.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Branco: 561.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 1123.25 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 561.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 1123.25 cm
El352 | TÉRREO | 2.56 | ø1" | 0.32 | 211.63 | 1" | Elétrica | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto leve - 1": 423.25 cm; Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - ref. Inbrac Polivinil Flex Antichama - 16 mm² - Verde-amarelo: 211.625 cm; Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - ref. Inbrac Polivinil Flex Antichama - 16 mm² - Azul claro: 211.625 cm; Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - ref. Inbrac Polivinil Flex Antichama - 16 mm² - Branco: 211.625 cm; Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - ref. Inbrac Polivinil Flex Antichama - 16 mm² - Preto: 211.625 cm; Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - ref. Inbrac Polivinil Flex Antichama - 16 mm² - Vermelho: 211.625 cm
El353 | TÉRREO | 1.94 | ø3/4" | 0.15 | 331.63 | 3/4" | Elétrica | 331.625 | 663.25 | 331.625 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 331.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Branco: 331.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 663.25 cm
El355 | TÉRREO | 1.94 | ø3/4" | 0.15 | 646.63 | 3/4" | Elétrica | 646.625 |  | 646.625 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 1293.25 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 1939.88 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 646.625 cm
El356 | TÉRREO | 1.94 | ø3/4" | 0.15 | 851.63 | 3/4" | Elétrica | 851.625 |  | 851.625 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 851.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 851.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 1703.25 cm
El357 | TÉRREO | 1.94 | ø3/4" | 0.15 | 90 | 3/4" | Elétrica | 90 | 90 | 90 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 90 cm
El358 | TÉRREO | 1.94 | ø3/4" | 0.15 | 60 | 3/4" | Elétrica | 60 | 60 | 60 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 60 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 60 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 60 cm
El359 | TÉRREO | 1.94 | ø3/4" | 0.15 | 90 | 3/4" | Elétrica | 90 | 90 | 90 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 90 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 90 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 90 cm
El36 | TÉRREO | 1.94 | ø3/4" | 0.15 | 435 | 3/4" | Elétrica | 435 | 435 | 435 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 435 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 435 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 435 cm
El360 | TÉRREO | 1.94 | ø3/4" | 0.15 | 445 | 3/4" | Elétrica | 445 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 890 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Branco: 445 cm
El362 | TÉRREO | 1.94 | ø3/4" | 0.15 | 420 | 3/4" | Elétrica | 420 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 420 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Verde-amarelo: 420 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Vermelho: 420 cm
El363 | TÉRREO | 1.94 | ø3/4" | 0.15 | 190 | 3/4" | Elétrica | 190 | 190 | 190 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 190 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 190 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 190 cm
El366 | TÉRREO | 1.94 | ø3/4" | 0.15 | 90 | 3/4" | Elétrica | 90 | 90 | 90 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 90 cm
El367 | TÉRREO | 1.94 | ø3/4" | 0.15 | 315 | 3/4" | Elétrica | 315 | 315 | 315 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 315 cm
El369 | TÉRREO | 1.94 | ø3/4" | 0.15 | 230 | 3/4" | Elétrica | 230 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Vermelho: 230 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 230 cm
El37 | TÉRREO | 1.94 | ø3/4" | 0.15 | 840 | 3/4" | Elétrica | 840 |  | 840 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 840 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 840 cm
El370 | TÉRREO | 1.94 | ø3/4" | 0.15 | 505 | 3/4" | Elétrica | 505 | 505 | 505 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 505 cm
El371 | TÉRREO | 1.94 | ø3/4" | 0.15 | 270 | 3/4" | Elétrica | 270 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 270 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Vermelho: 270 cm
El372 | TÉRREO | 1.94 | ø3/4" | 0.15 | 145 | 3/4" | Elétrica | 145 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 145 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Verde-amarelo: 145 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Branco: 145 cm
El373 | TÉRREO | 1.94 | ø3/4" | 0.15 | 305 | 3/4" | Elétrica | 305 | 610 | 305 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 305 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Branco: 305 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 610 cm
El374 | TÉRREO | 1.94 | ø3/4" | 0.15 | 330 | 3/4" | Elétrica | 330 | 330 | 330 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 330 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 330 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Branco: 330 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 330 cm
El375 | TÉRREO | 1.94 | ø3/4" | 0.15 | 355 | 3/4" | Elétrica | 355 | 355 | 355 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 355 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Branco: 355 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 355 cm
El376 | TÉRREO | 1.94 | ø3/4" | 0.15 | 270 | 3/4" | Elétrica | 270 | 540 | 270 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 540 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 270 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 540 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Preto: 270 cm
El377 | TÉRREO | 1.94 | ø3/4" | 0.15 | 180 | 3/4" | Elétrica | 180 | 180 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 360 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 540 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 180 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Preto: 180 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Verde-amarelo: 180 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Preto: 180 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Branco: 180 cm
El378 | TÉRREO | 1.94 | ø3/4" | 0.15 | 170 | 3/4" | Elétrica | 170 | 170 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 340 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 170 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 170 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Preto: 170 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Verde-amarelo: 170 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Preto: 170 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Branco: 170 cm
El379 | TÉRREO | 1.94 | ø3/4" | 0.15 | 160 | 3/4" | Elétrica | 160 | 160 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 320 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 160 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 160 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Preto: 160 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Verde-amarelo: 160 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Preto: 160 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Branco: 160 cm
El38 | TÉRREO | 1.94 | ø3/4" | 0.15 | 385 | 3/4" | Elétrica | 385 | 385 | 385 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 385 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Branco: 385 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 385 cm
El380 | TÉRREO | 1.94 | ø3/4" | 0.15 | 270 | 3/4" | Elétrica | 270 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 270 cm
El381 | TÉRREO | 1.94 | ø3/4" | 0.15 | 325 | 3/4" | Elétrica | 325 | 325 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 325 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Preto: 325 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Verde-amarelo: 325 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Branco: 325 cm
El382 | TÉRREO | 1.94 | ø3/4" | 0.15 | 90 | 3/4" | Elétrica | 90 | 90 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 90 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Preto: 90 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Verde-amarelo: 90 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Branco: 90 cm
El383 | TÉRREO | 1.94 | ø3/4" | 0.15 | 90 | 3/4" | Elétrica | 90 | 90 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 90 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Preto: 90 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Verde-amarelo: 90 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Vermelho: 90 cm
El384 | TÉRREO | 2.56 | ø1" | 0.32 | 425 | 1" | Elétrica |  | 1275 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 425 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 850 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Branco: 425 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 425 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 850 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Preto: 425 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Verde-amarelo: 425 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Vermelho: 425 cm; Eletroduto PVC flexível - Eletroduto leve - 1": 425 cm
El385 | TÉRREO | 1.94 | ø3/4" | 0.15 | 430 | 3/4" | Elétrica | 430 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 430 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Verde-amarelo: 430 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Preto: 430 cm
El386 | TÉRREO | 1.94 | ø3/4" | 0.15 | 190 | 3/4" | Elétrica | 190 | 190 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 190 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 190 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Branco: 190 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 190 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Preto: 190 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Verde-amarelo: 190 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Vermelho: 190 cm
El387 | TÉRREO | 1.94 | ø3/4" | 0.15 | 425 | 3/4" | Elétrica | 425 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 1275 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Preto: 425 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Verde-amarelo: 425 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Vermelho: 425 cm
El388 | TÉRREO | 1.94 | ø3/4" | 0.15 | 90 | 3/4" | Elétrica | 90 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Preto: 90 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Verde-amarelo: 90 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Vermelho: 90 cm
El389 | TÉRREO | 1.94 | ø3/4" | 0.15 | 90 | 3/4" | Elétrica | 90 |  | 90 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 90 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 90 cm
El39 | TÉRREO | 1.94 | ø3/4" | 0.15 | 1088.2 | 3/4" | Elétrica | 1088.2 | 1088.2 | 1088.2 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 2176.4 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Branco: 1088.2 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 1088.2 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 1088.2 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 1088.2 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Preto: 1088.2 cm
El390 | TÉRREO | 1.94 | ø3/4" | 0.15 | 375 | 3/4" | Elétrica | 375 |  | 375 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 375 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Branco: 375 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 375 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 375 cm
El391 | TÉRREO | 1.94 | ø3/4" | 0.15 | 395 | 3/4" | Elétrica | 395 | 395 | 395 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 395 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Branco: 395 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 395 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 395 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 395 cm
El392 | TÉRREO | 1.94 | ø3/4" | 0.15 | 140 | 3/4" | Elétrica | 140 | 280 | 140 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 140 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Branco: 140 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 140 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 140 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 280 cm
El393 | TÉRREO | 1.94 | ø3/4" | 0.15 | 50 | 3/4" | Elétrica | 50 | 50 | 50 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 50 cm
El394 | TÉRREO | 1.94 | ø3/4" | 0.15 | 90 | 3/4" | Elétrica | 90 | 90 | 90 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 90 cm
El395 | TÉRREO | 1.94 | ø3/4" | 0.15 | 100 | 3/4" | Elétrica | 100 |  | 100 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 100 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Branco: 100 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 100 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 100 cm
El396 | TÉRREO | 1.94 | ø3/4" | 0.15 | 190 | 3/4" | Elétrica | 190 | 190 | 190 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 190 cm
El397 | TÉRREO | 1.94 | ø3/4" | 0.15 | 90 | 3/4" | Elétrica | 90 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 90 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Branco: 90 cm
El398 | TÉRREO | 1.94 | ø3/4" | 0.15 | 150 | 3/4" | Elétrica | 150 | 150 | 150 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 150 cm
El399 | TÉRREO | 1.94 | ø3/4" | 0.15 | 465 | 3/4" | Elétrica | 465 | 465 | 465 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 465 cm
El4 | TÉRREO | 1.94 | ø3/4" | 0.15 | 139.63 | 3/4" | Elétrica | 139.625 |  | 139.625 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 139.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 139.625 cm
El40 | TÉRREO | 1.94 | ø3/4" | 0.15 | 180 | 3/4" | Elétrica | 180 | 180 | 180 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 360 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Branco: 180 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 180 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 180 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 180 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Preto: 180 cm
El400 | TÉRREO | 1.94 | ø3/4" | 0.15 | 710 | 3/4" | Elétrica | 710 |  | 710 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 710 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 710 cm
El401 | TÉRREO | 1.94 | ø3/4" | 0.15 | 260 | 3/4" | Elétrica | 260 |  | 260 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 260 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 520 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 260 cm
El402 | TÉRREO | 1.94 | ø3/4" | 0.15 | 110 | 3/4" | Elétrica | 110 | 110 | 110 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 110 cm
El403 | TÉRREO | 1.94 | ø3/4" | 0.15 | 355 | 3/4" | Elétrica | 355 | 355 | 355 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 355 cm
El404 | TÉRREO | 1.94 | ø3/4" | 0.15 | 150 | 3/4" | Elétrica | 150 | 300 | 150 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 150 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 150 cm
El405 | TÉRREO | 1.94 | ø3/4" | 0.15 | 325 | 3/4" | Elétrica | 325 | 325 | 325 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 325 cm
El408 | TÉRREO | 1.94 | ø3/4" | 0.15 | 90 | 3/4" | Elétrica | 90 | 90 | 90 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 90 cm
El409 | TÉRREO | 1.94 | ø3/4" | 0.15 | 365 | 3/4" | Elétrica | 365 | 365 | 365 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 365 cm
El41 | TÉRREO | 1.94 | ø3/4" | 0.15 | 395 | 3/4" | Elétrica | 395 | 395 | 395 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 395 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Branco: 395 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 395 cm
El410 | TÉRREO | 1.94 | ø3/4" | 0.15 | 240 | 3/4" | Elétrica | 240 | 480 | 240 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 240 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Branco: 240 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 240 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 240 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 480 cm
El411 | TÉRREO | 1.94 | ø3/4" | 0.15 | 220 | 3/4" | Elétrica | 220 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 220 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 220 cm
El412 | TÉRREO | 1.94 | ø3/4" | 0.15 | 280 | 3/4" | Elétrica | 280 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 280 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Vermelho: 280 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 280 cm
El414 | TÉRREO | 1.94 | ø3/4" | 0.15 | 335 | 3/4" | Elétrica | 335 | 335 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 335 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Branco: 335 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 335 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Preto: 335 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Verde-amarelo: 335 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Vermelho: 335 cm
El415 | TÉRREO | 1.94 | ø3/4" | 0.15 | 170 | 3/4" | Elétrica | 170 | 170 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 340 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Verde-amarelo: 170 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 170 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 170 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Preto: 170 cm
El416 | TÉRREO | 1.94 | ø3/4" | 0.15 | 415 | 3/4" | Elétrica | 415 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 415 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Verde-amarelo: 415 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Preto: 415 cm
El417 | TÉRREO | 1.94 | ø3/4" | 0.15 | 170 | 3/4" | Elétrica | 170 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 170 cm
El418 | TÉRREO | 1.94 | ø3/4" | 0.15 | 130 | 3/4" | Elétrica | 130 | 130 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 130 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Verde-amarelo: 130 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 130 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Preto: 130 cm
El419 | TÉRREO | 1.94 | ø3/4" | 0.15 | 170 | 3/4" | Elétrica | 170 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 170 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 170 cm
El42 | TÉRREO | 1.94 | ø3/4" | 0.15 | 135 | 3/4" | Elétrica | 135 | 135 | 135 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 135 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 135 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 135 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 135 cm
El420 | TÉRREO | 1.94 | ø3/4" | 0.15 | 190 | 3/4" | Elétrica | 190 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 190 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Vermelho: 190 cm
El422 | TÉRREO | 1.94 | ø3/4" | 0.15 | 170 | 3/4" | Elétrica | 170 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 170 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Verde-amarelo: 170 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Branco: 170 cm
El423 | TÉRREO | 1.94 | ø3/4" | 0.15 | 90 | 3/4" | Elétrica | 90 | 90 | 90 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 90 cm
El424 | TÉRREO | 1.94 | ø3/4" | 0.15 | 90 | 3/4" | Elétrica | 90 | 90 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 90 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Branco: 90 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 90 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Preto: 90 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Verde-amarelo: 90 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Vermelho: 90 cm
El425 | TÉRREO | 1.94 | ø3/4" | 0.15 | 90 | 3/4" | Elétrica | 90 | 90 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 90 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Branco: 90 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 90 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Preto: 90 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Verde-amarelo: 90 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 4 mm² - Vermelho: 90 cm
El426 | TÉRREO | 1.94 | ø3/4" | 0.15 | 45 | 3/4" | Elétrica | 45 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 45 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Verde-amarelo: 45 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Preto: 45 cm
El428 | TÉRREO | 1.94 | ø3/4" | 0.15 | 460 | 3/4" | Elétrica | 460 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 460 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Verde-amarelo: 460 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Branco: 460 cm
El429 | TÉRREO | 1.94 | ø3/4" | 0.15 | 260 | 3/4" | Elétrica | 260 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 260 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Verde-amarelo: 260 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Preto: 260 cm
El43 | TÉRREO | 1.94 | ø3/4" | 0.15 | 550 | 3/4" | Elétrica | 550 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 550 cm
El430 | TÉRREO | 1.94 | ø3/4" | 0.15 | 390 | 3/4" | Elétrica | 390 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 390 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Verde-amarelo: 390 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Preto: 390 cm
El431 | TÉRREO | 1.94 | ø3/4" | 0.15 | 390 | 3/4" | Elétrica | 390 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 390 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Verde-amarelo: 390 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Preto: 390 cm
El432 | TÉRREO | 1.94 | ø3/4" | 0.15 | 390 | 3/4" | Elétrica | 390 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 390 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Preto: 390 cm
El433 | TÉRREO | 1.94 | ø3/4" | 0.15 | 390 | 3/4" | Elétrica | 390 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 390 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Preto: 390 cm
El437 | TÉRREO | 1.94 | ø3/4" | 0.15 | 350 | 3/4" | Elétrica | 350 | 350 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 350 cm
El438 | TÉRREO | 1.94 | ø3/4" | 0.15 | 335 | 3/4" | Elétrica | 335 | 335 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 335 cm
El439 | TÉRREO | 1.94 | ø3/4" | 0.15 | 205 | 3/4" | Elétrica | 205 | 205 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 205 cm
El440 | TÉRREO | 1.94 | ø3/4" | 0.15 | 350 | 3/4" | Elétrica | 350 | 350 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 350 cm
El441 | TÉRREO | 1.94 | ø3/4" | 0.15 | 250 | 3/4" | Elétrica | 250 | 250 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 250 cm
El442 | TÉRREO | 1.94 | ø3/4" | 0.15 | 601.63 | 3/4" | Elétrica | 601.625 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 601.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Preto: 601.625 cm
El443 | TÉRREO | 1.94 | ø3/4" | 0.15 | 290 | 3/4" | Elétrica | 290 | 290 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 290 cm
El444 | TÉRREO | 1.94 | ø3/4" | 0.15 | 150 | 3/4" | Elétrica | 150 | 150 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 150 cm
El445 | TÉRREO | 1.94 | ø3/4" | 0.15 | 225 | 3/4" | Elétrica | 225 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 225 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Preto: 225 cm
El446 | TÉRREO | 1.94 | ø3/4" | 0.15 | 200 | 3/4" | Elétrica | 200 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 200 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Verde-amarelo: 200 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Preto: 200 cm
El447 | TÉRREO | 1.94 | ø3/4" | 0.15 | 495 | 3/4" | Elétrica | 495 | 495 | 495 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 495 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 495 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Preto: 495 cm
El448 | TÉRREO | 1.94 | ø3/4" | 0.15 | 160 | 3/4" | Elétrica | 160 | 160 | 160 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 160 cm
El45 | TÉRREO | 1.94 | ø3/4" | 0.15 | 430 | 3/4" | Elétrica | 430 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 430 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Verde-amarelo: 430 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Vermelho: 430 cm
El46 | TÉRREO | 1.94 | ø3/4" | 0.15 | 80 | 3/4" | Elétrica | 80 | 80 | 80 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 80 cm
El47 | TÉRREO | 1.94 | ø3/4" | 0.15 | 50 | 3/4" | Elétrica | 50 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 50 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Preto: 50 cm
El48 | TÉRREO | 1.94 | ø3/4" | 0.15 | 330 | 3/4" | Elétrica | 330 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 330 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Preto: 330 cm
El49 | TÉRREO | 1.94 | ø3/4" | 0.15 | 90 | 3/4" | Elétrica | 90 | 90 | 90 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 90 cm
El50 | TÉRREO | 1.94 | ø3/4" | 0.15 | 310 | 3/4" | Elétrica | 310 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 310 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 930 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Branco: 310 cm
El51 | TÉRREO | 1.94 | ø3/4" | 0.15 | 310 | 3/4" | Elétrica | 310 | 310 | 310 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 310 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 930 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Branco: 310 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 310 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 310 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 310 cm
El52 | TÉRREO | 1.94 | ø3/4" | 0.15 | 495 | 3/4" | Elétrica | 495 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 1485 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Branco: 495 cm
El53 | TÉRREO | 1.94 | ø3/4" | 0.15 | 405 | 3/4" | Elétrica | 405 |  | 405 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 405 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Branco: 405 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 405 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 405 cm
El54 | TÉRREO | 1.94 | ø3/4" | 0.15 | 375 | 3/4" | Elétrica | 375 | 375 | 375 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 375 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Branco: 375 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 375 cm
El55 | TÉRREO | 1.94 | ø3/4" | 0.15 | 320 | 3/4" | Elétrica | 320 | 640 | 320 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 320 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Branco: 320 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 640 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 320 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 320 cm
El56 | TÉRREO | 1.94 | ø3/4" | 0.15 | 90 | 3/4" | Elétrica | 90 |  | 90 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 90 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 90 cm
El57 | TÉRREO | 1.94 | ø3/4" | 0.15 | 140 | 3/4" | Elétrica | 140 | 140 | 140 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 140 cm
El58 | TÉRREO | 1.94 | ø3/4" | 0.15 | 400 | 3/4" | Elétrica | 400 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 400 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Verde-amarelo: 400 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Vermelho: 400 cm
El59 | TÉRREO | 1.94 | ø3/4" | 0.15 | 365 | 3/4" | Elétrica | 365 | 365 | 365 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 365 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Branco: 365 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 365 cm
El60 | TÉRREO | 1.94 | ø3/4" | 0.15 | 90 | 3/4" | Elétrica | 90 | 90 | 90 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 90 cm
El61 | TÉRREO | 1.94 | ø3/4" | 0.15 | 365 | 3/4" | Elétrica | 365 | 365 | 365 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Amarelo: 365 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Branco: 365 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 365 cm
El62 | TÉRREO | 1.94 | ø3/4" | 0.15 | 180 | 3/4" | Elétrica | 180 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 180 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Verde-amarelo: 180 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Branco: 180 cm
El64 | TÉRREO | 1.94 | ø3/4" | 0.15 | 688.38 | 3/4" | Elétrica | 688.375 |  | 688.375 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 688.375 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Preto: 688.375 cm
El65 | TÉRREO | 1.94 | ø3/4" | 0.15 | 90 | 3/4" | Elétrica | 90 | 90 | 90 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 90 cm
El66 | TÉRREO | 1.94 | ø3/4" | 0.15 | 120 | 3/4" | Elétrica | 120 | 120 | 120 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 120 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Branco: 120 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 120 cm
El67 | TÉRREO | 1.94 | ø3/4" | 0.15 | 10 | 3/4" | Elétrica | 10 |  | 10 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 10 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 10 cm
El68 | TÉRREO | 1.94 | ø3/4" | 0.15 | 260 | 3/4" | Elétrica | 260
El69 | TÉRREO | 1.94 | ø3/4" | 0.15 | 871.6 | 3/4" | Elétrica | 871.6 |  | 871.6 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 1743.2 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Vermelho: 1743.2 cm
El70 | TÉRREO | 1.94 | ø3/4" | 0.15 | 325 | 3/4" | Elétrica | 325 | 325 | 325 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 325 cm
El71 | TÉRREO | 1.94 | ø3/4" | 0.15 | 50 | 3/4" | Elétrica | 50 | 50 | 50 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 50 cm
El72 | TÉRREO | 1.94 | ø3/4" | 0.15 | 90 | 3/4" | Elétrica | 90 | 90 | 90 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 90 cm
El73 | TÉRREO | 1.94 | ø3/4" | 0.15 | 90 | 3/4" | Elétrica | 90 | 90 | 90 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 90 cm
El74 | TÉRREO | 1.94 | ø3/4" | 0.15 | 20 | 3/4" | Elétrica | 20 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 20 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Preto: 20 cm
El75 | TÉRREO | 1.94 | ø3/4" | 0.15 | 651.63 | 3/4" | Elétrica | 651.625 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 651.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Preto: 651.625 cm
El76 | TÉRREO | 1.94 | ø3/4" | 0.15 | 90 | 3/4" | Elétrica | 90 | 90 | 90 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 90 cm
El77 | TÉRREO | 1.94 | ø3/4" | 0.15 | 325 | 3/4" | Elétrica | 325 | 325 | 325 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 2.5 mm² - Branco: 325 cm
El78 | TÉRREO | 1.94 | ø3/4" | 0.15 | 160 | 3/4" | Elétrica | 160 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Azul claro: 160 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Inbrac Inbranil Flex Antichama - 1.5 mm² - Preto: 160 cm
