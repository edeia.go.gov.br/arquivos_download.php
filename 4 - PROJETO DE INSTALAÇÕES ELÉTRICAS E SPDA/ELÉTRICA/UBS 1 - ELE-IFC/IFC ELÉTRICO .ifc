Properties of the parts of a building model (IFC2X3), part 6 of 6

# IfcFlowTerminal: Classic (86)
Name | Fluxo luminoso para tensão 127V (lm) | Fluxo luminoso para tensão 220V (lm) | Potência (W) | Descrição | Nome | Circuito_1 | Comando_1 | Quadro_1
 | 2452 | 2454 | 19 | Lâmpada Led 19W | 19 W | 6 - Iluminação | b | QD2 | AltoQi_QiBuilder-Itens_Associados - Lâmpadas Led - Classic A - 35 W: 1
 | 2452 | 2454 | 19 | Lâmpada Led 19W | 19 W | 6 - Iluminação | c | QD2 | AltoQi_QiBuilder-Itens_Associados - Lâmpadas Led - Classic A - 35 W: 1
 | 2452 | 2454 | 19 | Lâmpada Led 19W | 19 W | 6 - Iluminação | d | QD2 | AltoQi_QiBuilder-Itens_Associados - Lâmpadas Led - Classic A - 35 W: 1
2 x  | 2452 | 2454 | 36 | Lâmpada Led 24W | 36 W | 6 - Iluminação | g | QD2 | AltoQi_QiBuilder-Itens_Associados - Lâmpadas Led - Classic - 36W: 1
 | 2452 | 2454 | 19 | Lâmpada Led 19W | 19 W | 6 - Iluminação | Nenhum | QD2 | AltoQi_QiBuilder-Itens_Associados - Lâmpadas Led - Classic A - 35 W: 1

# IfcFlowTerminal: Espeto embutir no piso (6)
In: TÉRREO
Type - PredefinedType: DIRECTIONSOURCE
AltoQi_Builder - Requer aterramento: Não; Comprimento: 15 cm; Largura: 15 cm; Profundidade: 11 cm; Posição: Piso
AltoQi_Builder-Ponto1 - Fator de potência (%): 50; Fluxo luminoso para tensão 127V: 280 lm; Fluxo luminoso para tensão 12V: 0 lm; Fluxo luminoso para tensão 220V: 280 lm; Número de lâmpadas: 1; Potência (W): 7; Quantidade: 1; Rendimento (%): 100; Tipo de luminária: A1 (Direta); Tipo de ponto: Lâmpada
Identificação_Elemento - Aplicação: Caixa; Descrição: Espeto embutir no piso; Nome: 7W; Classe: Lâmpadas Led; Tipo: Espeto embutir no piso; Rede: Elétrica
Circuito - Circuito_1: 9 - Iluminação; Comando_1: Nenhum; Pavimento_do_circuito_1: TÉRREO; Quadro_1: QD2
Pset_LightFixtureTypeCommon - Reference: Espeto embutir no piso
Pset_LightFixtureTypeCommon-Ponto1 - NumberOfSource: 1
Pset_ElectricalDeviceCommon - HasProtectiveEarth: Não
AltoQi_QiBuilder-Itens_Associados - Luminária e acessórios - Soquete - base E 27: 1; Lâmpadas Led - Espeto embutir piso - 7W: 1

# IfcFlowTerminal: Ponto de luz (2)
In: TÉRREO
Type - PredefinedType: DIRECTIONSOURCE
AltoQi_Builder - Requer aterramento: Sim; Comprimento: 7 cm; Largura: 4.75 cm; Profundidade: 10.85 cm; Posição: Alta
AltoQi_Builder-Ponto1 - Fator de potência (%): 100; Fluxo luminoso para tensão 127V: 800 lm; Fluxo luminoso para tensão 12V: 0 lm; Fluxo luminoso para tensão 220V: 800 lm; Número de lâmpadas: 1; Potência (W): 60; Quantidade: 1; Rendimento (%): 100; Tipo de luminária: A1 (Direta); Tipo de ponto: Lâmpada
Identificação_Elemento - Aplicação: Caixa; Descrição: Ponto genérico de luz 60W; Nome: 60 W (parede); Classe: Biblioteca BIM - Elétrica; Tipo: Ponto de luz; Rede: Elétrica
Circuito - Circuito_1: 51 - Iluminação; Comando_1: Nenhum; Pavimento_do_circuito_1: TÉRREO; Quadro_1: QD3
Pset_LightFixtureTypeCommon - Reference: Ponto de luz
Pset_LightFixtureTypeCommon-Ponto1 - NumberOfSource: 1
Pset_ElectricalDeviceCommon - HasProtectiveEarth: Sim
AltoQi_QiBuilder-Itens_Associados - Acessórios p/ eletrodutos - Caixa de Luz 4"x2" - 4"x 2": 1
