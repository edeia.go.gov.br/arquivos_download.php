Properties of the parts of a building model (IFC2X3), part 1 of 6

# File
Description: IFC2X3
Time: 2024-08-27T21:03:52
Made in: IfcPlusPlus

# IfcBuildingStorey (2)
Name | LongName | Elevation (cm)
TÉRREO | TÉRREO | 15
COBERTURA | COBERTURA | 365

# IfcFlowController: Aérea em poste - Ramal de entrada subterrâneo - Medição mesmo lado do poste, AL1
In: TÉRREO
Type - PredefinedType: ENERGYMETER
AltoQi_Builder - Comprimento: 30 cm; Largura: 10 cm; Profundidade: 30 cm; Indicação: DES. Nº 2-2/2; Posição: Alta; Esquema: 3F+N; Fases: R+S+T; Tensão: 220/127 V
Identificação_Elemento - Aplicação: Entrada de serviço; Descrição: Entrada de serviço aérea - Ramal Subterrâneo; Nome: Eletroduto PVC 1" (TN32) - Trifásico; Classe: Entrada de serviço - EDP; Tipo: Aérea em poste - Ramal de entrada subterrâneo - Medição mesmo lado do poste; Rede: Elétrica
Pset_FlowMeterTypeCommon - Reference: Aérea em poste - Ramal de entrada subterrâneo - Medição mesmo lado do poste
Pset_ElectricalDeviceCommon-Ponto1 - NominalCurrent: 125 A; NumberOfPoles: 3
AltoQi_QiBuilder-Itens_Associados - Acessórios p/ eletrodutos - Arruela zamak - 1.1/4": 1; Acessórios p/ eletrodutos - Bucha zamak - 1.1/4": 1; Acessórios p/ eletrodutos - Curva 90º PVC longa rosca - 1.1/4": 1; Eletroduto PVC flexível - Eletroduto pesado - 1.1/2": 100 cm; Eletroduto metálico rígido leve - Eletroduto galvanizado, vara 3,0m - 1.1/4": 100 cm; Material p/ entrada serviço - Arame de aço - 12 BWG: 1; Material p/ entrada serviço - Armação secundária aço laminado - 1 estribo com haste: 2; Material p/ entrada serviço - Isolador roldana 600V - Porcelana vidrada: 4; Material p/ entrada serviço - Massa de calafetar - 0,4kg: 1

# IfcFlowController: Edifício de uso coletivo - embutir, QM1
In: TÉRREO
Type - PredefinedType: ENERGYMETER
AltoQi_Builder - Comprimento: 26 cm; Largura: 17.73 cm; Profundidade: 52 cm; Indicação: Doc. 4140; Posição: Média; Esquema: 3F+N; Fases: R+S+T; Quadro Alimentador: AL1; Tensão: 220/127 V; DPS - Grupo: Dispositivo de proteção contra surto - DIN; DPS - Peça: 275 V - 40 kA; DPS - Quantidade: 4; Proteção - Grupo: Disjuntor tripolar termomagnético (220 V/127 V) - DIN; Proteção - Peça: 160 A - 40 kA - C
Identificação_Elemento - Aplicação: Quadro de medição; Descrição: Caixa de medição embutir a 1,60m do piso; Nome: Caixa tipo M; Classe: Quadro de medição - CPFL; Tipo: Edifício de uso coletivo - embutir; Rede: Elétrica
Pset_FlowMeterTypeCommon - Reference: Edifício de uso coletivo - embutir
Pset_ElectricalDeviceCommon-Ponto1 - NominalCurrent: 160 A; NumberOfPoles: 3; sets with these values: 2
AltoQi_QiBuilder-Itens_Associados - Dispositivo de Proteção - Disjuntor Tripolar Termomagnético - norma DIN - Curva C - 63 A - 3 kA: 1; Dispositivo de Proteção - Disjuntor Tripolar Termomagnético - norma DIN - Curva C - 90A - 10 kA: 1; Dispositivo de Proteção - Disjuntor bipolar termomagnético - 220 V/127 V - DIN - Curva C - 70 A - 5 kA: 1; Dispositivo de Proteção - Disjuntor tripolar termomagnético - 220 V/127 V - DIN - Curva C - 160 A - 40 kA: 1; Dispositivo de Proteção - Dispositivo de proteção contra surto - 275 V - 40 KA: 4; Quadro de medição - CPFL - Edifício de uso coletivo - embutir - Caixa medição tipo M - 8 medidores: 1

# IfcFlowFitting: Alvenaria - piso (2)
In: TÉRREO
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Comprimento: 30 cm; Largura: 30 cm; Profundidade: 30 cm; Indicação: 300x300x300; Posição: Piso
Identificação_Elemento - Aplicação: Caixa de passagem de fiação; Descrição: Caixa de passagem de embutir no piso; Nome: 300x300x300 mm; Classe: Caixa de passagem - embutir; Tipo: Alvenaria - piso; Rede: Elétrica
Pset_JunctionBoxTypeCommon - Reference: Alvenaria - piso
AltoQi_QiBuilder-Itens_Associados - Caixa de passagem - embutir - Alvenaria - 300x300x300mm: 1; Caixa de passagem - embutir - Alvenaria - Tampa 300x300x50mm: 1
Name
CX2
CX25

# IfcFlowFitting: Aço pintada - média (3)
In: TÉRREO
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Comprimento: 30 cm; Largura: 12 cm; Profundidade: 30 cm; Indicação: 300x300x120; Posição: Média
Identificação_Elemento - Aplicação: Caixa de passagem de fiação; Descrição: Caixa de passagem de embutir na parede; Nome: 300x300x120 mm; Classe: Caixa de passagem - embutir; Tipo: Aço pintada - média; Rede: Lógica
Pset_JunctionBoxTypeCommon - Reference: Aço pintada - média
AltoQi_QiBuilder-Itens_Associados - Caixa de passagem - embutir - Aço pintada - ref Lukbox - 300x300x120 mm: 1
Name
CX10
CX19
CX28

# IfcFlowFitting: Aço pintada - piso (4)
In: TÉRREO
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Posição: Piso
Identificação_Elemento - Aplicação: Caixa de passagem de fiação; Descrição: Caixa de passagem de embutir no piso; Classe: Caixa de passagem - embutir; Tipo: Aço pintada - piso
Pset_JunctionBoxTypeCommon - Reference: Aço pintada - piso
Name | Comprimento (cm) = Largura (cm) | Profundidade (cm) | Indicação | Nome | Rede
CX20 | 30 | 12 | 300x300x120 | 300x300x120 mm | Elétrica | AltoQi_QiBuilder-Itens_Associados - Caixa de passagem - embutir - Aço pintada - ref Lukbox - 300x300x120 mm: 1
CX24 | 20 | 10 | 200x200x100 | 200x200x100 mm | Elétrica | AltoQi_QiBuilder-Itens_Associados - Caixa de passagem - embutir - Aço pintada - ref Lukbox - 200x200x100 mm: 1
CX26 | 30 | 12 | 300x300x120 | 300x300x120 mm | Lógica | AltoQi_QiBuilder-Itens_Associados - Caixa de passagem - embutir - Aço pintada - ref Lukbox - 300x300x120 mm: 1
CX7 | 20 | 10 | 200x200x100 | 200x200x100 mm | Elétrica | AltoQi_QiBuilder-Itens_Associados - Caixa de passagem - embutir - Aço pintada - ref Lukbox - 200x200x100 mm: 1

# IfcFlowFitting: Aço pintada - teto, CX3
In: TÉRREO
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Comprimento: 20 cm; Largura: 20 cm; Profundidade: 10 cm; Indicação: 200x200x100; Posição: Teto
Identificação_Elemento - Aplicação: Caixa de passagem de fiação; Descrição: Caixa de passagem de embutir no teto; Nome: 200x200x100 mm; Classe: Caixa de passagem - embutir; Tipo: Aço pintada - teto; Rede: Elétrica
Pset_JunctionBoxTypeCommon - Reference: Aço pintada - teto
AltoQi_QiBuilder-Itens_Associados - Caixa de passagem - embutir - Aço pintada - ref Lukbox - 200x200x100 mm: 1

# IfcFlowFitting: Barr. bif., - DIN (Ref. Hager) (2)
In: TÉRREO
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Padrão das proteções: DIN; Largura: 9.75 cm; Posição: Média; Esquema: 2F+N; Tensão: 220/127 V; DPS - Grupo: Dispositivo de proteção contra surto - DIN; DPS - Peça: 175 V - 8 kA; DPS - Quantidade: 3; Proteção de Manutenção - Grupo: Disjuntor bipolar termomagnético (220 V/127 V) - DIN; Proteção - Grupo: Disjuntor bipolar termomagnético (220 V/127 V) - DIN
Identificação_Elemento - Aplicação: Quadro de distribuição; Descrição: Quadro de distribuição - embutir a 1,50m do piso; Classe: Quadro distrib. plástico - embutir; Tipo: Barr. bif., - DIN (Ref. Hager); Rede: Elétrica
Pset_JunctionBoxTypeCommon - Reference: Barr. bif., - DIN (Ref. Hager)
Pset_ElectricalDeviceCommon-Ponto1 - NumberOfPoles: 2
AltoQi_QiBuilder-Itens_Associados - Dispositivo de Proteção - Dispositivo de proteção contra surto - 175 V - 8 KA: 3
Name | Número de polos | Comprimento (cm) | Profundidade (cm) | Fases | Quadro Alimentador | Proteção de Manutenção - Peça | Proteção - Peça | Nome | Pset_ElectricalDeviceCommon-Ponto1, NominalCurrent (A)
QD1 | 12 | 27.5 | 22.5 | R+S | QD2 | 32 A - 5 kA - B | 32 A - 5 kA - C | Cap. 12 disj. unip. - In Pente 63A | 32 | Pset_ElectricalDeviceCommon-Ponto1 - sets with these values: 4; AltoQi_QiBuilder-Itens_Associados - Dispositivo de Proteção - Disjuntor Unipolar Termomagnético - norma DIN - Curva C - 10 A - 3 kA: 1; Dispositivo de Proteção - Disjuntor bipolar termomagnético - 220 V/127 V - DIN - Curva B - 16 A - 5 kA: 3; Dispositivo de Proteção - Disjuntor bipolar termomagnético - 220 V/127 V - DIN - Curva B - 32 A - 5 kA: 1; Dispositivo de Proteção - Interruptor tetrapolar DR - 3 fases/neutro - In 30mA - DIN - 40 A: 1; Quadro distrib. plástico - embutir - Barr. bif., - DIN - Ref. Hager - Cap. 12 disj. unip. - In Pente 63A: 1
QDAr 011 | 34 | 35.2 | 54.3 | R+T | QM1 | 70 A - 5 kA - C | 70 A - 5 kA - C | Cap. 34 disj. unip. - In Pente 100A | 70 | Pset_ElectricalDeviceCommon-Ponto2 - NominalCurrent: 70 A; NumberOfPoles: 2; AltoQi_QiBuilder-Itens_Associados - Dispositivo de Proteção - Disjuntor bipolar termomagnético - 220 V/127 V - DIN - Curva B - 20 A - 5 kA: 12; Dispositivo de Proteção - Disjuntor bipolar termomagnético - 220 V/127 V - DIN - Curva C - 70 A - 5 kA: 1; Quadro distrib. plástico - embutir - Barr. bif., - DIN - Ref. Hager - Cap. 34 disj. unip. - In Pente 100A: 1

# IfcFlowFitting: Barr. trif., - DIN (Ref. Hager) (2)
In: TÉRREO
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Número de polos: 84; Padrão das proteções: DIN; Comprimento: 45 cm; Largura: 10.3 cm; Profundidade: 50 cm; Posição: Média; Esquema: 3F+N; Fases: R+S+T; Quadro Alimentador: QM1; Tensão: 220/127 V; DPS - Grupo: Dispositivo de proteção contra surto - DIN; DPS - Peça: 175 V - 8 kA; DPS - Quantidade: 4; Proteção de Manutenção - Grupo: Disjuntor tripolar termomagnético - DIN; Proteção - Grupo: Disjuntor tripolar termomagnético - DIN
Identificação_Elemento - Aplicação: Quadro de distribuição; Descrição: Quadro de distribuição - embutir a 1,50m do piso; Nome: Cap. 84 disj. unip. - In Pente 100A; Classe: Quadro distrib. plástico - embutir; Tipo: Barr. trif., - DIN (Ref. Hager); Rede: Elétrica
Pset_JunctionBoxTypeCommon - Reference: Barr. trif., - DIN (Ref. Hager)
Pset_ElectricalDeviceCommon-Ponto1 - NumberOfPoles: 3
Pset_ElectricalDeviceCommon-Ponto2 - NumberOfPoles: 3; sets with these values: 2
AltoQi_QiBuilder-Itens_Associados - Dispositivo de Proteção - Dispositivo de proteção contra surto - 175 V - 8 KA: 4; Quadro distrib. plástico - embutir - Barr. trif., - DIN - Ref. Hager - Cap. 54 disj. unip. - In Pente 100A: 1
Name | Proteção de Manutenção - Peça = Proteção - Peça | Pset_ElectricalDeviceCommon-Ponto1, NominalCurrent (A) = Pset_ElectricalDeviceCommon-Ponto2, NominalCurrent (A) | Dispositivo de Proteção - Disjuntor Unipolar Termomagnético - norma DIN - Curva C - 16 A - 3 kA | Dispositivo de Proteção - Disjuntor bipolar termomagnético - 220 V/127 V - DIN - Curva B - 20 A - 5 kA
QD2 | 90 A - 10 kA - C | 90 | 24 | 9 | AltoQi_QiBuilder-Itens_Associados - Dispositivo de Proteção - Disjuntor Tripolar Termomagnético - norma DIN - Curva C - 90A - 10 kA: 1; Dispositivo de Proteção - Disjuntor bipolar termomagnético - 220 V/127 V - DIN - Curva B - 16 A - 5 kA: 2; Dispositivo de Proteção - Disjuntor bipolar termomagnético - 220 V/127 V - DIN - Curva C - 32 A - 5 kA: 1; Dispositivo de Proteção - Disjuntor bipolar termomagnético - 220 V/127 V - DIN - Curva C - 40 A - 5 kA: 2; Dispositivo de Proteção - Interruptor tetrapolar DR - 3 fases/neutro - In 30mA - DIN - 100 A: 1
QD3 | 63 A - 3 kA - C | 63 | 13 | 11 | AltoQi_QiBuilder-Itens_Associados - Dispositivo de Proteção - Disjuntor Tripolar Termomagnético - norma DIN - Curva C - 63 A - 3 kA: 1; Dispositivo de Proteção - Interruptor tetrapolar DR - 3 fases/neutro - In 30mA - DIN - 63 A: 1

# IfcFlowFitting: Curva horizontal 90º sem tampa
In: TÉRREO
Type - PredefinedType: BEND
AltoQi_Builder - Indicação: CH; Posição: Teto
Identificação_Elemento - Aplicação: Conexão; Descrição: Curva horizontal 90º; Nome: 100x50mm; Classe: Eletrocalha furada tipo U pré-galv. quen; Tipo: Curva horizontal 90º sem tampa; Rede: Elétrica
Pset_CableCarrierFittingTypeCommon - Reference: Curva horizontal 90º sem tampa
AltoQi_QiBuilder-Itens_Associados - Acessórios uso geral - Arruela lisa galvan. - 1/4": 16; Acessórios uso geral - Parafuso galvan. cabeça lentilha - 1/4"x5/8" máquina rosca total: 16; Acessórios uso geral - Porca sextavada galvan. - 1/4": 16; Eletrocalha furada tipo U pré-galv. quen - Curva horizontal 90° - 100x50mm chapa 18: 1; Eletrocalha furada tipo U pré-galv. quen - Tala plana perfurada - 50mm: 4

# IfcFlowFitting: Placa 2x4 (10)
In: TÉRREO
AltoQi_Builder - Requer aterramento: Não; Comprimento: 7 cm; Largura: 4.75 cm; Profundidade: 10.85 cm; Posição: Baixa
AltoQi_Builder-Ponto1 - Quantidade: 1; Tipo de ponto: Espera para TV
Identificação_Elemento - Aplicação: Caixa; Descrição: Ponto de TV a 0,30m do piso; Nome: tomada TV/SAT esse; Classe: Dispositivo TV/Som; Tipo: Placa 2x4; Rede: TV Cabo
Pset_JunctionBoxTypeCommon - Reference: Placa 2x4
AltoQi_QiBuilder-Itens_Associados - Acessórios p/ eletrodutos - Caixa PVC - 4x2": 1; Dispositivo TV/Som - Placa 2x4 - tomada TV/SAT: 1

# IfcFlowFitting: Placa cega - alta (18)
In: TÉRREO
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Comprimento: 7 cm; Largura: 4.75 cm; Profundidade: 10.85 cm; Indicação: 2x4"; Posição: Alta
Identificação_Elemento - Aplicação: Caixa de passagem de fiação; Descrição: Caixa 2x4" com placa cega de embutir na parede; Nome: 2x4"; Classe: Caixa de passagem - embutir; Tipo: Placa cega - alta; Rede: Elétrica
Pset_JunctionBoxTypeCommon - Reference: Placa cega - alta
AltoQi_QiBuilder-Itens_Associados - Acessórios p/ eletrodutos - Caixa PVC - 4x2": 1; Dispositivo Elétrico - embutido - Placa 2x4" - Placa cega: 1
Name
CX1
CX11
CX12
CX13
CX14
CX15
CX16
CX17
CX18
CX21
CX22
CX23
CX27
CX4
CX5
CX6
CX8
CX9

# IfcFlowFitting: Pontos de cabeamento (16)
In: TÉRREO
AltoQi_Builder - Requer aterramento: Não; Comprimento: 7 cm; Largura: 4.75 cm; Profundidade: 10.85 cm
AltoQi_Builder-Ponto1 - Quantidade: 1; Tipo de ponto: Espera para rede lógica
Identificação_Elemento - Aplicação: Caixa; Classe: Biblioteca BIM - Lógica; Tipo: Pontos de cabeamento; Rede: Lógica
Pset_JunctionBoxTypeCommon - Reference: Pontos de cabeamento
AltoQi_QiBuilder-Itens_Associados - Acessórios p/ eletrodutos - Caixa PVC - 4x2": 1; Dispositivo Lógica - embutir - Placa 2x4 - Tomada redonda RJ45: 1
Name | Posição | Descrição | Nome
13 x  | Baixa | Espera para rede lógica a 0,30m do piso | Espera para rede lógica
2 x  | Alta | Espera para rede lógica a 2,10 m do piso | Espera para rede lógica Alta
 | Média | Espera para rede lógica a 1,20 m do piso | Espera para rede lógica Média

# IfcFlowFitting: Pontos de comando (34)
In: TÉRREO
AltoQi_Builder - Requer aterramento: Não; Comprimento: 7 cm; Largura: 4.75 cm; Profundidade: 10.85 cm; Posição: Média
Identificação_Elemento - Aplicação: Caixa; Classe: Biblioteca BIM - Elétrica; Tipo: Pontos de comando; Rede: Elétrica
Circuito - Pavimento_do_circuito_1: TÉRREO
Pset_JunctionBoxTypeCommon - Reference: Pontos de comando
AltoQi_QiBuilder-Itens_Associados - Acessórios p/ eletrodutos - Caixa PVC - 4x2": 1
Name | AltoQi_Builder-Ponto1, Quantidade | AltoQi_Builder-Ponto1, Tipo de ponto | Descrição | Nome | Circuito_1 | Comando_1 | Quadro_1 | Dispositivo Elétrico - embutido - Placa 2x4" - Interruptor simples - 1 tecla
 | 1 | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | 50 - Iluminação | m1 | QD3 | 1
 | 1 | Interruptor paralelo | Interruptor 1 simples e 1 paralelo - 1,20m do piso | Interruptor simples e paralelo - 2 teclas | 50 - Iluminação | k1 | QD3 | AltoQi_Builder-Ponto2 - Quantidade: 1; Tipo de ponto: Interruptor simples; Circuito - Circuito_2: 50 - Iluminação; Comando_2: j1; Pavimento_do_circuito_2: TÉRREO; Quadro_2: QD3; AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Interruptor simples & paralelo - 2 teclas: 1
 | 1 | Interruptor paralelo | Interruptor paralelo 1 tecla - 1,20m do piso | Interruptor paralelo - 1 tecla | 6 - Iluminação | f | QD2 | Circuito - Circuito_2: 50 - Iluminação; Comando_2: j1; Pavimento_do_circuito_2: TÉRREO; Quadro_2: QD3; AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Interruptor paralelo - 1 tecla: 1
 | 1 | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | 50 - Iluminação | i1 | QD3 | 1
 | 1 | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | 50 - Iluminação | g1 | QD3 | 1
 | 1 | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | 50 - Iluminação | h1 | QD3 | 1
 | 1 | Interruptor paralelo | Interruptor paralelo 1 tecla - 1,20m do piso | Interruptor paralelo - 1 tecla | 50 - Iluminação | f1 | QD3 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Interruptor paralelo - 1 tecla: 1
 | 1 | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | 7 - Iluminação | m | QD2 | 1
 | 1 | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | 7 - Iluminação | p | QD2 | 1
 | 1 | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | 1 - Iluminação | a | QD1 | 1
 | 1 | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | 50 - Iluminação | n1 | QD3 | 1
 | 1 | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | 52 - Iluminação | o1 | QD3 | 1
 | 1 | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | 52 - Iluminação | p1 | QD3 | 1
 | 1 | Interruptor paralelo | Interruptor paralelo 1 tecla - 1,20m do piso | Interruptor paralelo - 1 tecla | 8 - Iluminação | e1 | QD2 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Interruptor paralelo - 1 tecla: 1
 | 2 | Interruptor paralelo | Interruptor paralelo 2 teclas - 1,20m do piso | Interruptor paralelo - 2 teclas | 8 - Iluminação | e1 | QD2 | Circuito - Circuito_2: 8 - Iluminação; Comando_2: x; Pavimento_do_circuito_2: TÉRREO; Quadro_2: QD2; AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Interruptor paralelo - 2 teclas: 1
 | 1 | Interruptor paralelo | Interruptor paralelo 1 tecla - 1,20m do piso | Interruptor paralelo - 1 tecla | 8 - Iluminação | x | QD2 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Interruptor paralelo - 1 tecla: 1
 | 1 | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | 6 - Iluminação | e | QD2 | 1
 | 1 | Interruptor paralelo | Interruptor 1 simples e 1 paralelo - 1,20m do piso | Interruptor simples e paralelo - 2 teclas | 7 - Iluminação | u | QD2 | AltoQi_Builder-Ponto2 - Quantidade: 1; Tipo de ponto: Interruptor simples; Circuito - Circuito_2: 7 - Iluminação; Comando_2: j; Pavimento_do_circuito_2: TÉRREO; Quadro_2: QD2; AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Interruptor simples & paralelo - 2 teclas: 1
 | 1 | Interruptor paralelo | Interruptor paralelo 1 tecla - 1,20m do piso | Interruptor paralelo - 1 tecla | 7 - Iluminação | j | QD2 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Interruptor paralelo - 1 tecla: 1
 | 1 | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | 7 - Iluminação | r | QD2 | 1
 | 1 | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | 7 - Iluminação | q | QD2 | 1
 | 1 | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | 7 - Iluminação | n | QD2 | 1
 | 1 | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | 7 - Iluminação | k | QD2 | 1
 | 1 | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | 7 - Iluminação | l | QD2 | 1
 | 1 | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | 7 - Iluminação | i | QD2 | 1
 | 1 | Interruptor paralelo | Interruptor paralelo 1 tecla - 1,20m do piso | Interruptor paralelo - 1 tecla | 6 - Iluminação | f | QD2 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Interruptor paralelo - 1 tecla: 1
 | 1 | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | 6 - Iluminação | h | QD2 | 1
 | 1 | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | 8 - Iluminação | c1 | QD2 | 1
 | 1 | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | 8 - Iluminação | w | QD2 | 1
2 x  | 1 | Interruptor paralelo | Interruptor paralelo 1 tecla - 1,20m do piso | Interruptor paralelo - 1 tecla | 8 - Iluminação | v | QD2 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Interruptor paralelo - 1 tecla: 1
 | 1 | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | 8 - Iluminação | y | QD2 | 1
 | 1 | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | 8 - Iluminação | z | QD2 | 1
 | 1 | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | 8 - Iluminação | b1 | QD2 | 1

# IfcFlowFitting: Pontos de comando e força (11)
In: TÉRREO
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Requer aterramento: Sim; Comprimento: 7 cm; Largura: 4.75 cm; Profundidade: 10.85 cm; Posição: Média
AltoQi_Builder-Ponto2 - Fator de potência (%): 90; Potência (W): 100; Quantidade: 1; Rendimento (%): 100; Tipo de ponto: Tomada 2P+T
AltoQi_Builder-Ponto1 - Quantidade: 1
Identificação_Elemento - Aplicação: Caixa; Classe: Biblioteca BIM - Elétrica; Tipo: Pontos de comando e força; Rede: Elétrica
Circuito - Pavimento_do_circuito_1: TÉRREO; Comando_2: Nenhum; Pavimento_do_circuito_2: TÉRREO
Pset_JunctionBoxTypeCommon - Reference: Pontos de comando e força
AltoQi_QiBuilder-Itens_Associados - Acessórios p/ eletrodutos - Caixa PVC - 4x2": 1; Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 2 funções: 1
Name | Tipo de ponto | Descrição | Nome | Circuito_1 | Comando_1 | Quadro_1 = Quadro_2 | Circuito_2 | Dispositivo Elétrico - embutido - S/ placa - Interruptor 1 tecla simples e tomada hexagonal - NBR14136
 | Interruptor simples | Interruptor simples e Tomada hexagonal a 1,20m do piso | Interruptor simples e Tomada hexagonal | 6 - Iluminação | d | QD2 | 32 - Tug's Sanitários e Almoxarifado | 1
 | Interruptor simples | Interruptor simples e Tomada hexagonal a 1,20m do piso | Interruptor simples e Tomada hexagonal | 6 - Iluminação | b | QD2 | 32 - Tug's Sanitários e Almoxarifado | 1
 | Interruptor simples | Interruptor simples e Tomada hexagonal a 1,20m do piso | Interruptor simples e Tomada hexagonal | 50 - Iluminação | l1 | QD3 | 66 - Tug's Sala e Sanit. Infantil | 1
 | Interruptor paralelo | Interruptor paralelo e Tomada hexagonal a 1,20m do piso | Interruptor paralelo e Tomada hexagonal | 50 - Iluminação | f1 | QD3 | 54 - Tug's Sala de Praticas | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - S/ placa - Interruptor 1 tecla paralela e tomada hexagonal - NBR14136: 1
 | Interruptor simples | Interruptor simples e Tomada hexagonal a 1,20m do piso | Interruptor simples e Tomada hexagonal | 6 - Iluminação | c | QD2 | 32 - Tug's Sanitários e Almoxarifado | 1
 | Interruptor simples | Interruptor simples e Tomada hexagonal a 1,20m do piso | Interruptor simples e Tomada hexagonal | 7 - Iluminação | t | QD2 | 10 - Tug's Resíduos, Banhos e DML | 1
 | Interruptor simples | Interruptor simples e Tomada hexagonal a 1,20m do piso | Interruptor simples e Tomada hexagonal | 7 - Iluminação | o | QD2 | 10 - Tug's Resíduos, Banhos e DML | 1
 | Interruptor simples | Interruptor simples e Tomada hexagonal a 1,20m do piso | Interruptor simples e Tomada hexagonal | 7 - Iluminação | s | QD2 | 10 - Tug's Resíduos, Banhos e DML | 1
 | Interruptor simples | Interruptor simples e Tomada hexagonal a 1,20m do piso | Interruptor simples e Tomada hexagonal | 6 - Iluminação | g | QD2 | 32 - Tug's Sanitários e Almoxarifado | 1
 | Interruptor simples | Interruptor simples e Tomada hexagonal a 1,20m do piso | Interruptor simples e Tomada hexagonal | 8 - Iluminação | d1 | QD2 | 35 - Tug's Reidratação | 1
 | Interruptor simples | Interruptor simples e Tomada hexagonal a 1,20m do piso | Interruptor simples e Tomada hexagonal | 8 - Iluminação | a1 | QD2 | 41 - Tug's Corredor | 1

# IfcFlowFitting: Pontos de força - Uso específico (28)
AltoQi_Builder - Requer aterramento: Sim
AltoQi_Builder-Ponto1 - Quantidade: 1; Tipo de ponto: Tomada 2P+T
Identificação_Elemento - Aplicação: Caixa; Classe: Biblioteca BIM - Elétrica; Tipo: Pontos de força - Uso específico; Rede: Elétrica
Circuito - Comando_1: Nenhum; Pavimento_do_circuito_1: TÉRREO
Pset_JunctionBoxTypeCommon - Reference: Pontos de força - Uso específico
AltoQi_QiBuilder-Itens_Associados - Acessórios p/ eletrodutos - Caixa PVC - 4x2": 1
Name | In | Comprimento (cm) | Largura (cm) | Profundidade (cm) | Indicação | Posição | Fator de potência (%) | Potência (W) | Rendimento (%) | Descrição | Nome | Circuito_1 | Quadro_1 | Dispositivo Elétrico - embutido - Placa 2x4" - Placa c/ furo
 | TÉRREO | 7 | 4.75 | 10.85 | 1/2cv | Baixa | 78 | 370 | 60.3 | Ponto para motor monofásico a 0,30m do piso | Bomba - 1/2cv monofásico | 29 - Bomba 01 | QD2 | 1
 | TÉRREO | 7 | 4.75 | 10.85 | 1/2cv | Baixa | 78 | 370 | 60.3 | Ponto para motor monofásico a 0,30m do piso | Bomba - 1/2cv monofásico | 30 - Bomba 02 | QD2 | 1
 | TÉRREO | 7 | 4.75 | 10.85 | 1/2cv | Baixa | 78 | 370 | 60.3 | Ponto para motor monofásico a 0,30m do piso | Bomba - 1/2cv monofásico | 2 - Bomba 01 | QD1 | 1
 | TÉRREO | 7 | 4.75 | 10.85 | 1/2cv | Baixa | 78 | 370 | 60.3 | Ponto para motor monofásico a 0,30m do piso | Bomba - 1/2cv monofásico | 3 - Bomba 02 | QD1 | 1
 | TÉRREO | 7 | 4.75 | 10.85 | 1/2cv | Baixa | 78 | 370 | 60.3 | Ponto para motor monofásico a 0,30m do piso | Bomba - 1/2cv monofásico | 4 - Bomba 03 | QD1 | 1
 | TÉRREO | 7 | 4.75 | 10.85 | PRT | Alta | 90 | 1000 | 100 | Tomada hexagonal (NBR 14136) - 2P+T 20 A específica para Portão Eletrônico | Portão Elétronico | 56 - Portão Eletrônico | QD3 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 20A: 1
 | TÉRREO | 7 | 4.75 | 10.85 | CHU | Alta | 100 | 5400 | 100 | Caixa 2x4 + Placa com furo a 2,20m do piso | Chuveiro 5400 W | 14 - Chuveiro 02 | QD2 | 1
 | TÉRREO | 7 | 4.75 | 10.85 | CHU | Alta | 100 | 5400 | 100 | Caixa 2x4 + Placa com furo a 2,20m do piso | Chuveiro 5400 W | 13 - Chuveiro 01 | QD2 | 1
 | TÉRREO | 7 | 4.75 | 10.85 | MOO | Média | 90 | 1500 | 100 | Tomada hexagonal (NBR 14136) - 2P+T 20 A | MICROONDAS | 16 - Microondas | QD2 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 20A: 1
 | TÉRREO | 7 | 4.75 | 10.85 | AC | Média | 100 | 2500 | 100 | Tomada hexagonal (NBR 14136) - 2P+T 20 A a 1,10m do piso | Autoclave | 21 - Autoclave | QD2 | 1
 | COBERTURA | 7 | 4.75 | 10.85 | ARC9000 | Alta | 90 | 815 | 100 | Tomada hexagonal (NBR 14136) - 2P+T 20 A a 2,20m do piso | Condicionador de ar Split 9000BTU | 73 - Ar Condicionado Recepção | QD3 | 1
 | COBERTURA | 7 | 4.75 | 10.85 | ARC18000 | Alta | 90 | 1630 | 100 | Tomada hexagonal (NBR 14136) - 2P+T 20 A a 2,20m do piso | Condicionador de ar Split 18000BTU | 91 - Ar Condicionado Fármacia | QDAr 011 | 1
 | COBERTURA | 7 | 4.75 | 10.85 | ARC9000 | Alta | 90 | 815 | 100 | Tomada hexagonal (NBR 14136) - 2P+T 20 A a 2,20m do piso | Condicionador de ar Split 9000BTU | 89 - Ar Condicionado Sala de Curativo | QDAr 011 | 1
 | COBERTURA | 7 | 4.75 | 10.85 | ARC9000 | Alta | 90 | 815 | 100 | Tomada hexagonal (NBR 14136) - 2P+T 20 A a 2,20m do piso | Condicionador de ar Split 9000BTU | 90 - Ar Condicionado Sala Multiprofissional | QDAr 011 | 1
 | COBERTURA | 7 | 4.75 | 10.85 | ARC12000 | Alta | 90 | 1085 | 100 | Tomada hexagonal (NBR 14136) - 2P+T 20 A a 2,20m do piso | Condicionador de ar Split 12000BTU | 88 - Ar Condicionado Cons. Gineco | QDAr 011 | 1
 | COBERTURA | 7 | 4.75 | 10.85 | ARC12000 | Alta | 90 | 1085 | 100 | Tomada hexagonal (NBR 14136) - 2P+T 20 A a 2,20m do piso | Condicionador de ar Split 12000BTU | 87 - Ar Condicionado Reidratação | QDAr 011 | 1
 | COBERTURA | 7 | 4.75 | 10.85 | ARC12000 | Alta | 90 | 1085 | 100 | Tomada hexagonal (NBR 14136) - 2P+T 20 A a 2,20m do piso | Condicionador de ar Split 12000BTU | 84 - Ar Condicionado Aplicação de Medicamento | QDAr 011 | 1
 | COBERTURA | 7 | 4.75 | 10.85 | ARC12000 | Alta | 90 | 1085 | 100 | Tomada hexagonal (NBR 14136) - 2P+T 20 A a 2,20m do piso | Condicionador de ar Split 12000BTU | 82 - Ar Condicionado Esterilização | QDAr 011 | 1
 | COBERTURA | 7 | 4.75 | 10.85 | ARC9000 | Alta | 90 | 815 | 100 | Tomada hexagonal (NBR 14136) - 2P+T 20 A a 2,20m do piso | Condicionador de ar Split 9000BTU | 86 - Ar Condicionado Cons. Indiferenciado | QDAr 011 | 1
 | COBERTURA | 7 | 4.75 | 10.85 | ARC9000 | Alta | 90 | 815 | 100 | Tomada hexagonal (NBR 14136) - 2P+T 20 A a 2,20m do piso | Condicionador de ar Split 9000BTU | 81 - Ar Condicionado Sala de Gestão | QDAr 011 | 1
 | COBERTURA | 7 | 4.75 | 10.85 | ARC18000 | Alta | 90 | 1630 | 100 | Tomada hexagonal (NBR 14136) - 2P+T 20 A a 2,20m do piso | Condicionador de ar Split 18000BTU | 80 - Ar Condicionado Sala Multiuso | QDAr 011 | 1
 | COBERTURA | 7 | 4.75 | 10.85 | ARC12000 | Alta | 90 | 1085 | 100 | Tomada hexagonal (NBR 14136) - 2P+T 20 A a 2,20m do piso | Condicionador de ar Split 12000BTU | 83 - Ar Condicionado Odonto | QDAr 011 | 1
 | COBERTURA | 15 | 15 | 11 | ARC9000 | Piso | 90 | 815 | 100 | Tomada hexagonal (NBR 14136) - 2P+T 20 A a 2,20m do piso | Condicionador de ar Split 9000BTU | 79 - Ar Condicionado Copa | QDAr 011 | 1
 | COBERTURA | 7 | 4.75 | 10.85 | ARC9000 | Alta | 90 | 815 | 100 | Tomada hexagonal (NBR 14136) - 2P+T 20 A a 2,20m do piso | Condicionador de ar Split 9000BTU | 69 - Ar Condicionado Amamentação | QD3 | 1
 | COBERTURA | 7 | 4.75 | 10.85 | ARC24000 | Alta | 90 | 2200 | 100 | Tomada hexagonal (NBR 14136) - 2P+T 20 A a 2,20m do piso | Condicionador de ar Split 24000BTU | 68 - Ar Condicionado Sala Práticas | QD3 | 1
 | COBERTURA | 7 | 4.75 | 10.85 | ARC9000 | Alta | 90 | 815 | 100 | Tomada hexagonal (NBR 14136) - 2P+T 20 A a 2,20m do piso | Condicionador de ar Split 9000BTU | 71 - Ar Condicionado Acolhimento | QD3 | 1
 | COBERTURA | 7 | 4.75 | 10.85 | ARC9000 | Alta | 90 | 815 | 100 | Tomada hexagonal (NBR 14136) - 2P+T 20 A a 2,20m do piso | Condicionador de ar Split 9000BTU | 70 - Ar Condicionado Sala de Vacina | QD3 | 1
 | COBERTURA | 7 | 4.75 | 10.85 | ARC36000 | Alta | 90 | 3500 | 100 | Tomada hexagonal (NBR 14136) - 2P+T 20 A a 2,20m do piso | Condicionador de ar Split 36000BTU | 72 - Ar Condicionado Espera | QD3 | 1

# IfcFlowFitting: Pontos de força - Uso geral (175)
In: TÉRREO
AltoQi_Builder - Requer aterramento: Sim; Comprimento: 7 cm
AltoQi_Builder-Ponto1 - Fator de potência (%): 90; Potência (W): 100; Rendimento (%): 100; Tipo de ponto: Tomada 2P+T
Identificação_Elemento - Aplicação: Caixa; Classe: Biblioteca BIM - Elétrica; Tipo: Pontos de força - Uso geral; Rede: Elétrica
Circuito - Comando_1: Nenhum; Pavimento_do_circuito_1: TÉRREO
Pset_JunctionBoxTypeCommon - Reference: Pontos de força - Uso geral
Name | Largura (cm) | Profundidade (cm) | Posição | Quantidade | Descrição | Nome | Circuito_1 | Quadro_1 | Acessórios p/ eletrodutos - Caixa PVC - 4x2" | Circuito_2 | Comando_2 | Pavimento_do_circuito_2 | Quadro_2 | Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 2 funções
4 x  | 4.75 | 10.85 | Média | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 1,20m do piso | 2P+T 10 A - média | 42 - Tug's Sala Multiprofissional | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1
 | 4.75 | 10.85 | Baixa | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A + 20A | 2P+T 10 A e 20A baixa | 32 - Tug's Sanitários e Almoxarifado | QD2 | 1 | 43 - Tug's 220v | Nenhum | TÉRREO | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 20A: 1; AltoQi_Builder-Ponto1 - sets with these values: 2
2 x  | 4.75 | 10.85 | Média | 2 | 2 Tomadas hexagonais (NBR 14136) - 2P+T 10 A a 1,20m do piso | 2P+T 10A (2) - média | 31 - Tug's Farmácia | QD2 | 1 | 31 - Tug's Farmácia | Nenhum | TÉRREO | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 10A: 1
 | 4.75 | 10.85 | Baixa | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10 A - baixa | 31 - Tug's Farmácia | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1
 | 4.75 | 10.85 | Baixa | 2 | 2 Tomadas hexagonais (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10A (2) - baixa | 31 - Tug's Farmácia | QD2 | 1 | 31 - Tug's Farmácia | Nenhum | TÉRREO | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 10A: 1
2 x  | 4.75 | 10.85 | Média | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 1,20m do piso | 2P+T 10 A - média | 31 - Tug's Farmácia | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1
 | 4.75 | 10.85 | Baixa | 2 | 2 Tomadas hexagonais (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10A (2) - baixa | 31 - Tug's Farmácia | QD2 | 1 | 43 - Tug's 220v | Nenhum | TÉRREO | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 10A: 1
 | 4.75 | 10.85 | Baixa | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10 A - baixa | 66 - Tug's Sala e Sanit. Infantil | QD3 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1
 | 4.75 | 10.85 | Baixa | 2 | 2 Tomadas hexagonais (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10A (2) - baixa | 66 - Tug's Sala e Sanit. Infantil | QD3 | 1 | 66 - Tug's Sala e Sanit. Infantil | Nenhum | TÉRREO | QD3 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 10A: 1
 | 4.75 | 10.85 | Média | 2 | 2 Tomadas hexagonais (NBR 14136) - 2P+T 10 A a 1,20m do piso | 2P+T 10A (2) - média | 66 - Tug's Sala e Sanit. Infantil | QD3 | 1 | 66 - Tug's Sala e Sanit. Infantil | Nenhum | TÉRREO | QD3 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 10A: 1
3 x  | 4.75 | 10.85 | Média | 2 | 2 Tomadas hexagonais (NBR 14136) - 2P+T 10 A a 1,20m do piso | 2P+T 10A (2) - média | 65 - Tug's Recepção | QD3 | 1 | 65 - Tug's Recepção | Nenhum | TÉRREO | QD3 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 10A: 1
2 x  | 4.75 | 10.85 | Média | 3 | 3 Tomadas hexagonais (NBR 14136) - 2P+T 10 A a 1,10m do piso | 2P+T 10A (3) - média | 64 - Tug's Recepção | QD3 | 1 | 64 - Tug's Recepção | Nenhum | TÉRREO | QD3 | 1 | Circuito - Circuito_3: 64 - Tug's Recepção; Comando_3: Nenhum; Pavimento_do_circuito_3: TÉRREO; Quadro_3: QD3; AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 3 - 2P+T 10A: 1
2 x  | 4.75 | 10.85 | Baixa | 2 | 2 Tomadas hexagonais (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10A (2) - baixa | 64 - Tug's Recepção | QD3 | 1 | 64 - Tug's Recepção | Nenhum | TÉRREO | QD3 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 10A: 1
 | 4.75 | 10.85 | Baixa | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A + 20A | 2P+T 10 A e 20A baixa | 63 - Tug's 220v | QD3 | 1 | 65 - Tug's Recepção | Nenhum | TÉRREO | QD3 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 20A: 1; AltoQi_Builder-Ponto1 - sets with these values: 2
 | 4.75 | 10.85 | Baixa | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A + 20A | 2P+T 10 A e 20A baixa | 60 - Tug's Espera | QD3 | 1 | 55 - Tug's 220v | Nenhum | TÉRREO | QD3 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 20A: 1; AltoQi_Builder-Ponto1 - sets with these values: 2
 | 4.75 | 10.85 | Baixa | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10 A - baixa | 75 - Tug's 220v | QD3 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1
 | 4.75 | 10.85 | Baixa | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10 A - baixa | 59 - Tug's Sala de Acolhimento | QD3 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1
 | 4.75 | 10.85 | Baixa | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10 A - baixa | 65 - Tug's Recepção | QD3 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1
 | 4.75 | 10.85 | Baixa | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A + 20A | 2P+T 10 A e 20A baixa | 60 - Tug's Espera | QD3 | 1 | 63 - Tug's 220v | Nenhum | TÉRREO | QD3 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 20A: 1; AltoQi_Builder-Ponto1 - sets with these values: 2
 | 4.75 | 10.85 | Média | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 1,20m do piso | 2P+T 10 A - média | 60 - Tug's Espera | QD3 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1
2 x  | 4.75 | 10.85 | Baixa | 2 | 2 Tomadas hexagonais (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10A (2) - baixa | 60 - Tug's Espera | QD3 | 1 | 60 - Tug's Espera | Nenhum | TÉRREO | QD3 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 10A: 1
3 x  | 4.75 | 10.85 | Baixa | 2 | 2 Tomadas hexagonais (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10A (2) - baixa | 59 - Tug's Sala de Acolhimento | QD3 | 1 | 59 - Tug's Sala de Acolhimento | Nenhum | TÉRREO | QD3 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 10A: 1
 | 4.75 | 10.85 | Baixa | 2 | 2 Tomadas hexagonais (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10A (2) - baixa | 59 - Tug's Sala de Acolhimento | QD3 | 1 | 75 - Tug's 220v | Nenhum | TÉRREO | QD3 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 10A: 1
 | 4.75 | 10.85 | Média | 2 | 2 Tomadas hexagonais (NBR 14136) - 2P+T 10 A a 1,20m do piso | 2P+T 10A (2) - média | 59 - Tug's Sala de Acolhimento | QD3 | 1 | 59 - Tug's Sala de Acolhimento | Nenhum | TÉRREO | QD3 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 10A: 1
 | 4.75 | 10.85 | Média | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 1,20m do piso | 2P+T 10 A - média | 59 - Tug's Sala de Acolhimento | QD3 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1
2 x  | 4.75 | 10.85 | Baixa | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10 A - baixa | 74 - Tug's 220v | QD3 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1
2 x  | 4.75 | 10.85 | Baixa | 2 | 2 Tomadas hexagonais (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10A (2) - baixa | 58 - Tug's Sala de Vacina | QD3 | 1 | 58 - Tug's Sala de Vacina | Nenhum | TÉRREO | QD3 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 10A: 1
2 x  | 4.75 | 10.85 | Baixa | 2 | 2 Tomadas hexagonais (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10A (2) - baixa | 57 - Tug's Sala de Amamentação | QD3 | 1 | 57 - Tug's Sala de Amamentação | Nenhum | TÉRREO | QD3 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 10A: 1
3 x  | 4.75 | 10.85 | Média | 2 | 2 Tomadas hexagonais (NBR 14136) - 2P+T 10 A a 1,20m do piso | 2P+T 10A (2) - média | 58 - Tug's Sala de Vacina | QD3 | 1 | 58 - Tug's Sala de Vacina | Nenhum | TÉRREO | QD3 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 10A: 1
 | 4.75 | 10.85 | Média | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 1,20m do piso | 2P+T 10 A - média | 58 - Tug's Sala de Vacina | QD3 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1
 | 4.75 | 10.85 | Média | 2 | 2 Tomadas hexagonais (NBR 14136) - 2P+T 10 A a 1,20m do piso | 2P+T 10A (2) - média | 57 - Tug's Sala de Amamentação | QD3 | 1 | 57 - Tug's Sala de Amamentação | Nenhum | TÉRREO | QD3 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 10A: 1
 | 4.75 | 10.85 | Média | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 1,20m do piso | 2P+T 10 A - média | 57 - Tug's Sala de Amamentação | QD3 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1
2 x  | 4.75 | 10.85 | Baixa | 2 | 2 Tomadas hexagonais (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10A (2) - baixa | 54 - Tug's Sala de Praticas | QD3 | 1 | 54 - Tug's Sala de Praticas | Nenhum | TÉRREO | QD3 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 10A: 1
2 x  | 4.75 | 10.85 | Média | 2 | 2 Tomadas hexagonais (NBR 14136) - 2P+T 10 A a 1,20m do piso | 2P+T 10A (2) - média | 54 - Tug's Sala de Praticas | QD3 | 1 | 54 - Tug's Sala de Praticas | Nenhum | TÉRREO | QD3 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 10A: 1
 | 4.75 | 10.85 | Baixa | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10 A - baixa | 55 - Tug's 220v | QD3 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1
 | 4.75 | 10.85 | Baixa | 2 | 2 Tomadas hexagonais (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10A (2) - baixa | 54 - Tug's Sala de Praticas | QD3 | 1 | 55 - Tug's 220v | Nenhum | TÉRREO | QD3 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 10A: 1
2 x  | 4.75 | 10.85 | Média | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 1,20m do piso | 2P+T 10 A - média | 53 - Tug's Sala de Práticas | QD3 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1
3 x  | 4.75 | 10.85 | Baixa | 2 | 2 Tomadas hexagonais (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10A (2) - baixa | 53 - Tug's Sala de Práticas | QD3 | 1 | 53 - Tug's Sala de Práticas | Nenhum | TÉRREO | QD3 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 10A: 1
 | 4.75 | 10.85 | Média | 2 | 2 Tomadas hexagonais (NBR 14136) - 2P+T 10 A a 1,20m do piso | 2P+T 10A (2) - média | 53 - Tug's Sala de Práticas | QD3 | 1 | 53 - Tug's Sala de Práticas | Nenhum | TÉRREO | QD3 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 10A: 1
 | 4.75 | 10.85 | Baixa | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A + 20A | 2P+T 10 A e 20A baixa | 59 - Tug's Sala de Acolhimento | QD3 | 1 | 75 - Tug's 220v | Nenhum | TÉRREO | QD3 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 20A: 1; AltoQi_Builder-Ponto1 - sets with these values: 2
 | 4.75 | 10.85 | Baixa | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10 A - baixa | 44 - Tug's Sala de Gestão | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1
2 x  | 4.75 | 10.85 | Baixa | 2 | 2 Tomadas hexagonais (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10A (2) - baixa | 44 - Tug's Sala de Gestão | QD2 | 1 | 44 - Tug's Sala de Gestão | Nenhum | TÉRREO | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 10A: 1
 | 4.75 | 10.85 | Média | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 1,20m do piso | 2P+T 10 A - média | 44 - Tug's Sala de Gestão | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1
2 x  | 4.75 | 10.85 | Média | 2 | 2 Tomadas hexagonais (NBR 14136) - 2P+T 10 A a 1,20m do piso | 2P+T 10A (2) - média | 44 - Tug's Sala de Gestão | QD2 | 1 | 44 - Tug's Sala de Gestão | Nenhum | TÉRREO | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 10A: 1
 | 4.75 | 10.85 | Baixa | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A + 20A | 2P+T 10 A e 20A baixa | 44 - Tug's Sala de Gestão | QD2 | 1 | 12 - Tug's 220v | Nenhum | TÉRREO | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 20A: 1; AltoQi_Builder-Ponto1 - sets with these values: 2
 | 4.75 | 10.85 | Baixa | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A + 20A | 2P+T 10 A e 20A baixa | 36 - Tug's Aplicação de Medicamentos | QD2 | 1 | 33 - Tug's 220v | Nenhum | TÉRREO | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 20A: 1; AltoQi_Builder-Ponto1 - sets with these values: 2
3 x  | 4.75 | 10.85 | Baixa | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10 A - baixa | 10 - Tug's Resíduos, Banhos e DML | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1
 | 4.75 | 10.85 | Baixa | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A + 20A | 2P+T 10 A e 20A baixa | 10 - Tug's Resíduos, Banhos e DML | QD2 | 1 | 11 - Tug's 220v | Nenhum | TÉRREO | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 20A: 1; AltoQi_Builder-Ponto1 - sets with these values: 2
 | 4.75 | 10.85 | Baixa | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A + 20A | 2P+T 10 A e 20A baixa | 54 - Tug's Sala de Praticas | QD3 | 1 | 55 - Tug's 220v | Nenhum | TÉRREO | QD3 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 20A: 1; AltoQi_Builder-Ponto1 - sets with these values: 2
 | 4.75 | 10.85 | Baixa | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A + 20A | 2P+T 10 A e 20A baixa | 65 - Tug's Recepção | QD3 | 1 | 63 - Tug's 220v | Nenhum | TÉRREO | QD3 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 20A: 1; AltoQi_Builder-Ponto1 - sets with these values: 2
3 x  | 4.75 | 10.85 | Baixa | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10 A - baixa | 23 - Tug's Odonto | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1
 | 4.75 | 10.85 | Baixa | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10 A - baixa | 19 - Tug's 220v | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1
 | 4.75 | 10.85 | Média | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 1,20m do piso | 2P+T 10 A - média | 20 - Tug's Paramentação e Esterilização | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1
3 x  | 10.85 | 4.75 | Piso | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A no piso | 2P+T 10 A - piso | 64 - Tug's Recepção | QD3 | AltoQi_QiBuilder-Itens_Associados - Acessórios p/ eletrodutos - Caixa alumínio 4"x2" - 3x4": 1; Dispositivo Elétrico - embutido - Placa 2x4" - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1
2 x  | 4.75 | 10.85 | Baixa | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10 A - baixa | 36 - Tug's Aplicação de Medicamentos | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1
3 x  | 4.75 | 10.85 | Média | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 1,20m do piso | 2P+T 10 A - média | 36 - Tug's Aplicação de Medicamentos | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1
 | 4.75 | 10.85 | Baixa | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10 A - baixa | 15 - Tug's Copa | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1
 | 4.75 | 10.85 | Média | 2 | 2 Tomadas hexagonais (NBR 14136) - 2P+T 20 A a 1,20m do piso | 2P+T 20A (2) - média | 15 - Tug's Copa | QD2 | 1 | 12 - Tug's 220v | Nenhum | TÉRREO | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 20A: 1
3 x  | 4.75 | 10.85 | Média | 1 | Tomada hexagonal (NBR 14136) - 2P+T 20 A a 1,20m do piso | 2P+T 20 A - média | 15 - Tug's Copa | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 20A: 1
 | 4.75 | 10.85 | Baixa | 2 | 2 Tomadas hexagonais (NBR 14136) - 2P+T 20 A a 0,30m do piso | 2P+T 20A (2) - baixa | 15 - Tug's Copa | QD2 | 1 | 12 - Tug's 220v | Nenhum | TÉRREO | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 20A: 1
 | 4.75 | 10.85 | Baixa | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10 A - baixa | 12 - Tug's 220v | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1
2 x  | 4.75 | 10.85 | Baixa | 2 | 2 Tomadas hexagonais (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10A (2) - baixa | 18 - Tug's Sala Multiuso | QD2 | 1 | 18 - Tug's Sala Multiuso | Nenhum | TÉRREO | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 10A: 1
2 x  | 4.75 | 10.85 | Média | 2 | 2 Tomadas hexagonais (NBR 14136) - 2P+T 10 A a 1,20m do piso | 2P+T 10A (2) - média | 18 - Tug's Sala Multiuso | QD2 | 1 | 18 - Tug's Sala Multiuso | Nenhum | TÉRREO | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 10A: 1
 | 4.75 | 10.85 | Média | 1 | Tomada hexagonal (NBR 14136) - 2P+T 20 A a 1,20m do piso | 2P+T 20 A - média | 44 - Tug's Sala de Gestão | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 20A: 1
2 x  | 4.75 | 10.85 | Baixa | 2 | 2 Tomadas hexagonais (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10A (2) - baixa | 17 - Tug's Sala Multiuso | QD2 | 1 | 17 - Tug's Sala Multiuso | Nenhum | TÉRREO | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 10A: 1
3 x  | 4.75 | 10.85 | Média | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 1,20m do piso | 2P+T 10 A - média | 17 - Tug's Sala Multiuso | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1
 | 4.75 | 10.85 | Baixa | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10 A - baixa | 17 - Tug's Sala Multiuso | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1
 | 4.75 | 10.85 | Média | 2 | 2 Tomadas hexagonais (NBR 14136) - 2P+T 10 A a 1,20m do piso | 2P+T 10A (2) - média | 17 - Tug's Sala Multiuso | QD2 | 1 | 17 - Tug's Sala Multiuso | Nenhum | TÉRREO | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 10A: 1
 | 4.75 | 10.85 | Baixa | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10 A - baixa | 11 - Tug's 220v | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1
 | 4.75 | 10.85 | Baixa | 2 | 2 Tomadas hexagonais (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10A (2) - baixa | 10 - Tug's Resíduos, Banhos e DML | QD2 | 1 | 10 - Tug's Resíduos, Banhos e DML | Nenhum | TÉRREO | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 10A: 1
 | 4.75 | 10.85 | Média | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 1,20m do piso | 2P+T 10 A - média | 10 - Tug's Resíduos, Banhos e DML | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1
 | 4.75 | 10.85 | Média | 1 | Tomada hexagonal (NBR 14136) - 2P+T 20 A a 1,20m do piso | 2P+T 20 A - média | 20 - Tug's Paramentação e Esterilização | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 20A: 1
3 x  | 4.75 | 10.85 | Baixa | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10 A - baixa | 20 - Tug's Paramentação e Esterilização | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1
 | 4.75 | 10.85 | Média | 2 | 2 Tomadas hexagonais (NBR 14136) - 2P+T 10 A a 1,20m do piso | 2P+T 10A (2) - média | 20 - Tug's Paramentação e Esterilização | QD2 | 1 | 20 - Tug's Paramentação e Esterilização | Nenhum | TÉRREO | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 10A: 1
 | 4.75 | 10.85 | Média | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 1,10m do piso | 2P+T 10 A e 20A média | 20 - Tug's Paramentação e Esterilização | QD2 | 1 | 19 - Tug's 220v | Nenhum | TÉRREO | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 20A: 1; AltoQi_Builder-Ponto1 - sets with these values: 2
 | 4.75 | 10.85 | Baixa | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A + 20A | 2P+T 10 A e 20A baixa | 22 - Tug's Expurgo | QD2 | 1 | 19 - Tug's 220v | Nenhum | TÉRREO | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 20A: 1; AltoQi_Builder-Ponto1 - sets with these values: 2
 | 4.75 | 10.85 | Baixa | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10 A - baixa | 22 - Tug's Expurgo | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1
 | 4.75 | 10.85 | Média | 1 | Tomada hexagonal (NBR 14136) - 2P+T 20 A a 1,20m do piso | 2P+T 20 A - média | 22 - Tug's Expurgo | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 20A: 1
 | 4.75 | 10.85 | Média | 1 | Tomada hexagonal (NBR 14136) - 2P+T 20 A a 1,20m do piso | 2P+T 20 A - média | 23 - Tug's Odonto | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 20A: 1
