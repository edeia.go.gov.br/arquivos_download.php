Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
Time: 2024-07-31T12:01:35
Made in: IfcPlusPlus

# IfcBuildingStorey (2)
Name | LongName | Elevation (cm)
TÉRREO | TÉRREO | 15
COBERTURA | COBERTURA | 365

# IfcFlowController: Barramento de equipotencialização
In: TÉRREO
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Comprimento: 21 cm; Largura: 9 cm; Profundidade: 21 cm; Indicação: BEP; Posição: Média
Identificação_Elemento - Aplicação: Barramento de equipotencialização; Descrição: BEP - 9 terminais 210x210x90mm Metálica; Nome: 9 terminais 210x210x90mm Metálica; Classe: SPDA - Aterramento; Tipo: Barramento de equipotencialização; Rede: SPDA
Pset_ProtectiveDeviceTypeCommon - Reference: Barramento de equipotencialização
AltoQi_QiBuilder-Itens_Associados - Aterramento - Barramento de equipotencialização - 9 terminais: 1

# IfcFlowController: Captor Franklin
In: COBERTURA
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Altura: 625 cm; Posição: Teto
Identificação_Elemento - Aplicação: Captor; Descrição: Captor Franklin - H=250mm - 1 descida; Nome: H=250mm - 01 descida (c/ mastro simples 6m x ø1.1/2"); Classe: SPDA - Captor; Tipo: Captor Franklin; Rede: SPDA
Pset_ProtectiveDeviceTypeCommon - Reference: Captor Franklin
AltoQi_QiBuilder-Itens_Associados - Captores - Captor Franklin - H=250mm - 01 descida: 1; Captores - Mastro simples - 6m x ø1.1/2": 1

# IfcFlowController: Isolador simples (5)
In: COBERTURA
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Posição: Teto
Identificação_Elemento - Aplicação: Isolador; Descrição: Isolador simples - fix. c/ chapa de encosto - 100 mm; Nome: Fix. c/ chapa de encosto - 100 mm; Classe: SPDA - Condutores; Tipo: Isolador simples; Rede: SPDA
Pset_ProtectiveDeviceTypeCommon - Reference: Isolador simples
AltoQi_QiBuilder-Itens_Associados - Condutores de proteção - SPDA - Isolador simples - Fix. c/ chapa de encosto - 100 mm: 1

# IfcFlowController: Terminal Aéreo (24)
In: COBERTURA
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Altura: 30 cm; Posição: Teto
Identificação_Elemento - Aplicação: Captor; Descrição: Terminal Aéreo - 300 mm - Fixação horizontal; Nome: 300 mm - Fixação horizontal; Classe: SPDA - Captor; Tipo: Terminal Aéreo; Rede: SPDA
Pset_ProtectiveDeviceTypeCommon - Reference: Terminal Aéreo
AltoQi_QiBuilder-Itens_Associados - Captores - Terminal Aéreo - 300 mm - Fixação horizontal: 1

# IfcFlowFitting: Aço pintada - baixa (9)
In: TÉRREO
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Comprimento: 10 cm; Largura: 8 cm; Profundidade: 10 cm; Indicação: 100x100x80; Posição: Baixa
Identificação_Elemento - Aplicação: Caixa de passagem de fiação; Descrição: Caixa de passagem de sobrepor na parede; Nome: 100x100x80 mm; Classe: Caixa de passagem - sobrepor; Tipo: Aço pintada - baixa; Rede: Elétrica
Pset_JunctionBoxTypeCommon - Reference: Aço pintada - baixa
AltoQi_QiBuilder-Itens_Associados - Caixa de passagem - sobrepor - Aço pintada - ref Lukbox - 100x100x80 mm: 1
Name
CX1
CX2
CX3
CX4
CX5
CX6
CX7
CX8
CX9

# IfcFlowFitting: Caixa de inspeção (9)
In: TÉRREO
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Comprimento: 30 cm; Largura: 30 cm; Profundidade: 30 cm; Posição: Piso
Identificação_Elemento - Aplicação: Caixa de inspeção; Descrição: Caixa de inspeção - Cimento - Ø300x300m c/ haste 3/4" x 2,40m; Nome: Cimento - Ø300x300mm c/ haste 3/4" x 2,40; Classe: SPDA - Aterramento; Tipo: Caixa de inspeção; Rede: SPDA
Pset_JunctionBoxTypeCommon - Reference: Caixa de inspeção
AltoQi_QiBuilder-Itens_Associados - Aterramento - Caixa de inspeção - Cimento - Ø300x300mm: 1; Aterramento - Haste de aterramento - cobreada - 3/4" x 2,40m: 1
Name
CXi1
CXi10
CXi11
CXi3
CXi4
CXi5
CXi6
CXi8
CXi9

# IfcFlowSegment: Cabo de cobre nú (Encordoado) (115)
Type - PredefinedType: CONDUCTORSEGMENT
AltoQi_Builder - Comprimento máximo: 300 cm
Identificação_Elemento - Classe: SPDA - Condutos; Tipo: Cabo de cobre nú (Encordoado); Rede: SPDA; Aplicação: Cordoalha
Pset_CableSegmentTypeCommon - Reference: Cabo de cobre nú (Encordoado)
Pset_CableSegmentTypeConductorSegment - CrossSectionalArea: 0 m2
Name | In | Indicação = Nome | Seção (mm²) | Condutores de proteção - SPDA - Cabo de cobre Nú - 7 fios - 35mm² (cm)
 | TÉRREO | 50mm² | 50 | AltoQi_QiBuilder-Itens_Associados - Condutores de proteção - SPDA - Cabo de cobre Nú - 7 fios - 50mm²: 1577.42 cm
 | TÉRREO | 50mm² | 50 | AltoQi_QiBuilder-Itens_Associados - Condutores de proteção - SPDA - Cabo de cobre Nú - 7 fios - 50mm²: 1591.03 cm
 | TÉRREO | 50mm² | 50 | AltoQi_QiBuilder-Itens_Associados - Condutores de proteção - SPDA - Cabo de cobre Nú - 7 fios - 50mm²: 247.496 cm
 | TÉRREO | 50mm² | 50 | AltoQi_QiBuilder-Itens_Associados - Condutores de proteção - SPDA - Cabo de cobre Nú - 7 fios - 50mm²: 278.822 cm
 | TÉRREO | 50mm² | 50 | AltoQi_QiBuilder-Itens_Associados - Condutores de proteção - SPDA - Cabo de cobre Nú - 7 fios - 50mm²: 1220 cm
 | TÉRREO | 50mm² | 50 | AltoQi_QiBuilder-Itens_Associados - Condutores de proteção - SPDA - Cabo de cobre Nú - 7 fios - 50mm²: 339.761 cm
 | TÉRREO | 50mm² | 50 | AltoQi_QiBuilder-Itens_Associados - Condutores de proteção - SPDA - Cabo de cobre Nú - 7 fios - 50mm²: 990.003 cm
 | TÉRREO | 50mm² | 50 | AltoQi_QiBuilder-Itens_Associados - Condutores de proteção - SPDA - Cabo de cobre Nú - 7 fios - 50mm²: 930.058 cm
 | TÉRREO | 50mm² | 50 | AltoQi_QiBuilder-Itens_Associados - Condutores de proteção - SPDA - Cabo de cobre Nú - 7 fios - 50mm²: 959.996 cm
 | TÉRREO | 50mm² | 50 | AltoQi_QiBuilder-Itens_Associados - Condutores de proteção - SPDA - Cabo de cobre Nú - 7 fios - 50mm²: 128.059 cm
9 x  | TÉRREO | 35mm² | 35 | 260 | AltoQi_QiBuilder-Itens_Associados - Condutores de proteção - SPDA - Duto de Proteção - Tubos de PVC de 1" x 3m: 1
 | TÉRREO | 35mm² | 35 | 149.31
9 x  | TÉRREO | 35mm² | 35 | 90
 | TÉRREO | 35mm² | 35 | 148.55
 | TÉRREO | 50mm² | 50 | AltoQi_QiBuilder-Itens_Associados - Condutores de proteção - SPDA - Cabo de cobre Nú - 7 fios - 50mm²: 1557.07 cm
 | TÉRREO | 35mm² | 35 | 99.5353
 | TÉRREO | 35mm² | 35 | 151.849
 | TÉRREO | 35mm² | 35 | 147.701
 | TÉRREO | 35mm² | 35 | 148.149
 | TÉRREO | 35mm² | 35 | 147.305
 | TÉRREO | 35mm² | 35 | 148.62
 | TÉRREO | 35mm² | 35 | 148.735
 | TÉRREO | 50mm² | 50 | AltoQi_QiBuilder-Itens_Associados - Condutores de proteção - SPDA - Cabo de cobre Nú - 7 fios - 50mm²: 1214.83 cm
 | TÉRREO | 50mm² | 50 | AltoQi_QiBuilder-Itens_Associados - Condutores de proteção - SPDA - Cabo de cobre Nú - 7 fios - 50mm²: 492.808 cm
 | TÉRREO | 50mm² | 50 | AltoQi_QiBuilder-Itens_Associados - Condutores de proteção - SPDA - Cabo de cobre Nú - 7 fios - 50mm²: 90.0313 cm
 | COBERTURA | 35mm² | 35 | 259.572
 | COBERTURA | 35mm² | 35 | 39.0283
2 x  | COBERTURA | 35mm² | 35 | 444.121
 | COBERTURA | 35mm² | 35 | 259.836
 | COBERTURA | 35mm² | 35 | 39.1104
 | COBERTURA | 35mm² | 35 | 39.0297
 | COBERTURA | 35mm² | 35 | 4.54015
 | COBERTURA | 35mm² | 35 | 39.0454
 | COBERTURA | 35mm² | 35 | 39.0471
 | COBERTURA | 35mm² | 35 | 270.755
 | COBERTURA | 35mm² | 35 | 123.246
 | COBERTURA | 35mm² | 35 | 100.865
 | COBERTURA | 35mm² | 35 | 99.7767
 | COBERTURA | 35mm² | 35 | 100.292
 | COBERTURA | 35mm² | 35 | 100.518
 | COBERTURA | 35mm² | 35 | 129.648
 | COBERTURA | 35mm² | 35 | 800 | AltoQi_QiBuilder-Itens_Associados - Condutores de proteção - SPDA - Duto de Proteção - Tubos de PVC de 1" x 3m: 1
 | COBERTURA | 35mm² | 35 | 11.8643
 | COBERTURA | 35mm² | 35 | 61.0081
 | COBERTURA | 35mm² | 35 | 353.191
 | COBERTURA | 35mm² | 35 | 149.003
 | COBERTURA | 35mm² | 35 | 990.507
 | COBERTURA | 35mm² | 35 | 1286.42
 | COBERTURA | 35mm² | 35 | 171.002
 | COBERTURA | 35mm² | 35 | 10.2257
 | COBERTURA | 35mm² | 35 | 11.7349
 | COBERTURA | 35mm² | 35 | 210.002
 | COBERTURA | 35mm² | 35 | 11.2976
 | COBERTURA | 35mm² | 35 | 171.004
 | COBERTURA | 35mm² | 35 | 10.9125
2 x  | COBERTURA | 35mm² | 35 | 171
 | COBERTURA | 35mm² | 35 | 12.5383
 | COBERTURA | 35mm² | 35 | 171.003
 | COBERTURA | 35mm² | 35 | 12.5254
 | COBERTURA | 35mm² | 35 | 171.001
 | COBERTURA | 35mm² | 35 | 10.8497
 | COBERTURA | 35mm² | 35 | 11.0984
 | COBERTURA | 35mm² | 35 | 210.008
 | COBERTURA | 35mm² | 35 | 781.72
 | COBERTURA | 35mm² | 35 | 395.24
 | COBERTURA | 35mm² | 35 | 394.889
 | COBERTURA | 35mm² | 35 | 13.4031
 | COBERTURA | 35mm² | 35 | 66.0043
 | COBERTURA | 35mm² | 35 | 5.04528
2 x  | COBERTURA | 35mm² | 35 | 505.129
2 x  | COBERTURA | 35mm² | 35 | 663.87
 | COBERTURA | 35mm² | 35 | 248.901
 | COBERTURA | 35mm² | 35 | 11.7025
 | COBERTURA | 35mm² | 35 | 79.1834
 | COBERTURA | 35mm² | 35 | 255.707
 | COBERTURA | 35mm² | 35 | 470.824
 | COBERTURA | 35mm² | 35 | 255.878
 | COBERTURA | 35mm² | 35 | 981.998
 | COBERTURA | 35mm² | 35 | 739.455
 | COBERTURA | 35mm² | 35 | 354.997
 | COBERTURA | 35mm² | 35 | 231.435
2 x  | COBERTURA | 35mm² | 35 | 767.651
 | COBERTURA | 35mm² | 35 | 421.014
 | COBERTURA | 35mm² | 35 | 11.4679
 | COBERTURA | 35mm² | 35 | 1284.06
2 x  | COBERTURA | 35mm² | 35 | 369.036
 | COBERTURA | 35mm² | 35 | 382.047
 | COBERTURA | 35mm² | 35 | 354.313
 | COBERTURA | 35mm² | 35 | 400.099
2 x  | COBERTURA | 35mm² | 35 | 260
 | COBERTURA | 35mm² | 35 | 250
 | COBERTURA | 35mm² | 35 | 360.186
